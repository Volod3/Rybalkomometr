/*
  Рибалкометр v1.0
  На базі AlexGyver MeteoClock v1.5
  Адаптовано під ESP32 + розпіновка Вови
*/

// ------------------------- НАЛАШТУВАННЯ --------------------
#define RESET_CLOCK 0         // 1 = скинути годинник на час компіляції, потім поставити 0
#define SENS_TIME 30000       // читання датчиків, мс
#define DRAW_TIME 10000       // оновлення дисплея, мс

// Яскравість — 3 рівні залежно від LDR
#define BRIGHT_LOW    500     // нижче цього = тьмяно
#define BRIGHT_HIGH   2500    // вище цього = максимум (між — середній)
#define LCD_BRIGHT_MIN  50    // тьмяний рівень дисплея (0-255)
#define LCD_BRIGHT_MID  160   // середній рівень дисплея
#define LCD_BRIGHT_MAX  255   // максимум дисплея
#define LED_BRIGHT_MIN  40    // тьмяний рівень RGB
#define LED_BRIGHT_MID  120   // середній рівень RGB
#define LED_BRIGHT_MAX  255   // максимум RGB

#define DISP_MODE 1           // 0-рік, 1-день тижня, 2-секунди
#define WEEK_LANG 0           // 0-англ, 1-укр транслітом

// Межі графіків
#define TEMP_MIN  -10
#define TEMP_MAX   40
#define HUM_MIN    0
#define HUM_MAX    100
// PRESS_MIN/MAX більше не фіксовані — межі графіку тиску розраховуються динамічно
// відносно SEA_PRESS_MM (базовий тиск місцевості) ±30 мм. Див. pressPlotMin()/pressPlotMax().

#define DISPLAY_ADDR 0x27

// Динамічні межі графіку тиску: ±30 мм від базового тиску місцевості (×10 бо масив у 0.1 мм).
// Якщо SEA_PRESS_MM ще не задано (==0) — fallback 745 мм (середина загального діапазону).
extern float SEA_PRESS_MM;  // визначена нижче як глобальна змінна
inline int pressPlotMin() {
  float base = (SEA_PRESS_MM > 0.0f) ? SEA_PRESS_MM : 745.0f;
  return (int)((base - 30.0f) * 10.0f);
}
inline int pressPlotMax() {
  float base = (SEA_PRESS_MM > 0.0f) ? SEA_PRESS_MM : 745.0f;
  return (int)((base + 30.0f) * 10.0f);
}

// ------------------------- ПІНИ ESP32 ----------------------
#define BACKLIGHT   15    // підсвітка LCD (BL на I2C модулі)
#define PHOTO_PIN   34    // фоторезистор (ADC1)
#define LED_R_PIN   13
#define LED_G_PIN   12
#define LED_B_PIN   14
#define BTN_PIN      4    // TTP223

// LEDC канали
#define CH_BL    0
#define CH_R     1
#define CH_G     2
#define CH_B     3

// ------------------------- WiFi AP -------------------------
#define AP_SSID     "RybalkAP"
#define AP_PASS     "fish1234"
#define AP_IP       "192.168.4.1"

// ------------------------- БІБЛІОТЕКИ ----------------------
#include <Arduino.h>
#include <Wire.h>
#include <LiquidCrystal_I2C.h>
#include <RTClib.h>
#include <Adafruit_Sensor.h>
#include <Adafruit_BME280.h>
#include <Preferences.h>
#include <WiFi.h>
#include <WebServer.h>
#include <HTTPClient.h>
#include <ArduinoJson.h>
#include <time.h>
#include <math.h>               // sin, cos, asin, acos, atan2, fmod, floor
#include <esp_task_wdt.h>   // ESP32 Task Watchdog Timer

// ------------------------- ГЛОБАЛЬНІ ОБ'ЄКТИ ---------------
// Mutex для HTTPClient: всі HTTP-запити (fetchForecast, fetchRealtimeWeather, fetchBasePress,
// geocodeCity) виконуються у FreeRTOS-тасках на різних ядрах, тому потрібен захист.
// Ініціалізується в setup() до запуску будь-яких тасків.
SemaphoreHandle_t httpMutex = NULL;

bool apActive = false;
bool apManual = false;       // true = AP вмикав юзер вручну (довго тримав кнопку)
bool staWebActive = false;   // веб-сервер запущено через STA (роутер)
WebServer webServer(80);
bool apBlink = false;
uint32_t apBlinkTimer = 0;

// Глобальні об'єкти
LiquidCrystal_I2C lcd(DISPLAY_ADDR, 20, 4);
RTC_DS3231 rtc;
DateTime now;
Adafruit_BME280 bme;

// Базовий тиск місцевості — завантажується з Preferences при старті
float SEA_PRESS_MM = 0.0f;
// Два слоти тиску місцевості (A і B). Активний — SEA_PRESS_MM.
float pressSlotA = 0.0f;
float pressSlotB = 0.0f;
byte  pressActiveSlot = 0; // 0=A, 1=B
// Два слоти координат (A і B). Активний — cityLat/cityLon.
float coordLatA = 0.0f, coordLonA = 0.0f;
float coordLatB = 0.0f, coordLonB = 0.0f;
byte  coordActiveSlot = 0; // 0=A, 1=B
// Стандартний тиск на рівні моря для розрахунку висоти (не змінюється)
#define STD_SEA_PRESS_MM 760.0f

// -------- ЧАСОВИЙ ПОЯС --------
// 0=авто (EU DST: UTC+2 зима, UTC+3 літо), 1=UTC+2 (фіксовано), 2=UTC+3 (фіксовано)
byte tzMode = 0;

// Повертає поточний UTC-зсув у секундах.
// EU DST: остання неділя березня 01:00 UTC → UTC+3; остання неділя жовтня 01:00 UTC → UTC+2
int32_t getUtcOffset() {
  if (tzMode == 1) return 7200;   // фіксовано UTC+2
  if (tzMode == 2) return 10800;  // фіксовано UTC+3

  // Авто: визначаємо EU DST за поточним RTC (локальний UTC+2/+3 — різниця ±1 год несуттєва)
  DateTime n = rtc.now();
  byte mo  = n.month();
  byte day = n.day();
  byte dow = n.dayOfTheWeek(); // 0=Sun
  byte h   = n.hour();

  // Поза перехідними місяцями
  if (mo > 3 && mo < 10) return 10800;  // UTC+3 (літо)
  if (mo < 3 || mo > 10) return 7200;   // UTC+2 (зима)

  // Останній тиждень: день >= 25 і неділя (dow==0)
  bool isLastSunday = (dow == 0 && day >= 25);

  if (mo == 3) {
    // Перехід на літній: остання неділя березня о 01:00 UTC (03:00 UTC+2)
    if (!isLastSunday) return (day < 25) ? 7200 : 10800; // до/після
    return (h >= 3) ? 10800 : 7200;
  } else { // mo == 10
    // Перехід на зимовий: остання неділя жовтня о 01:00 UTC (03:00 UTC+3)
    if (!isLastSunday) return (day < 25) ? 10800 : 7200;
    return (h >= 4) ? 7200 : 10800; // 04:00 UTC+3 = 01:00 UTC
  }
}

// Forward declarations
void loadClock();
void loadPlot();
void drawClock(byte hours, byte minutes, byte x, byte y, bool dotState);
void drawData();
void drawSensors();
void redrawPlot();
void updateFishLED();
void startAP();
void stopAP();
void drawWifiScreen();
void drawApBadge();
byte getSeason();
byte getSeasonTransition(byte &fromSeason, byte &toSeason);
void tryConnectWifi();
void wifiSyncTick();
bool fetchForecast();
bool fetchSunTimes();
bool geocodeCity(const char* city);
int  forecastCurrentIdx();
void loadWifiNets();
void loadForecast();
void saveSunTimes();
void loadSunTimes();
void setupWebServer();
float fetchBasePress();
byte getMoonPhase();
const char* moonPhaseName(byte p);
const char* moonPhaseIcon(byte p);
int moonBonus();
bool basePressureSet();
bool startupWarmup();
const char* seasonName(byte season);
String seasonDisplayName();
int timeBonusForSeason(byte season, byte h);
float forecastAvgTemp(int start, int count);
int tempTrendC();
const char* windFromName(uint16_t deg);
const char* windTargetShore(uint16_t deg);
String comfortText();
String futureBiteText();
void resetRuntimePressureState();
void factoryResetRuntime();
bool isSpawnPeriod();
int spawnScoreAdjust();
bool startupPreliminary();
void updateDayCache();
bool fetchRealtimeWeather();

// ------------------------- ЗМІННІ --------------------------
int8_t hrs, mins, secs;
byte mode = 0;
/*
  0 — годинник + дані
  1 — графік температури за день
  2 — графік вологості за день
  3 — графік тиску за годину
  4 — графік тиску за день
  5 — екран WiFi AP (SSID, пароль, IP)
  6 — графік кльову за день
*/

float dispTemp;
byte  dispHum;
float dispPres;
int   dispRain;   // шанс дощу 0..100 (без мінусів)

int tempDay[15], humDay[15];
int pressHour[15], pressDay[15];  // зберігаємо у 0.1 мм (×10) для точності графіку
// tempHour і humHour тільки для усереднення денного графіку
int tempHour[15], humHour[15];
// Графік кльову за день (15 точок × 96 хв ≈ 24 год), 0-3 (Bad/50%/Good/Grt)
int fishHour[15];

int delta;
bool deltaReady = false;  // false поки не пройшло 10 хв і delta не розраховано

// Налаштування кльову (зберігаються в NVS)
// 0=мирна вся, 1=хижа, 2=карась, 3=короп, 4=змішана К+Кр, 5=змішана вся мирна
byte fishType    = 0;
bool useTime     = true; // враховувати час доби
bool useSpawn    = true; // враховувати нерест (за замовч. увімкнено)
bool useMoon     = true; // враховувати фазу місяця (невеликий бонус/штраф)
byte waterType   = 0;   // 0=озеро/ставок, 1=річка


// Адаптація риби до нового тиску
float adaptPress       = 0.0f;  // тиск на якому риба зараз "адаптована"
uint32_t stableStartMs = 0;     // коли тиск стабілізувався після стрибка
bool pressJumped       = false; // стрибок зафіксовано, йде адаптація
float jumpMagnitudeMm  = 0.0f;  // величина стрибка тиску в мм
uint32_t jumpStartMs   = 0;     // час початку стрибка
byte jumpExtraHits     = 0;     // додаткові удари під час стрибка
uint32_t lastAdaptDoneMs = 0;   // коротка пам'ять завершеної адаптації
float lastAdaptPress     = 0.0f;
uint32_t lastAdaptCreditMs = 0;
uint32_t pressure_array[6];
byte pressureSampleCount = 0;
int64_t sumX, sumY, sumX2, sumXY;
float a;
byte time_array[6] = {0,1,2,3,4,5};

// EMA (Exponential Moving Average) для фільтрації мікрошуму тиску (±0.1–0.3 мм).
// alpha=0.07: добре відфільтровує шум, при стрибку >3 мм — скидається миттєво.
float   smoothedPress      = 0.0f;
bool    smoothedPressInit  = false;
#define EMA_ALPHA  0.07f

// Збереження стану між перезапусками (в RTC SRAM через Wire напряму)
Preferences prefs;

// Зберегти налаштування (викликається одразу при зміні будь-якого параметру)
void saveSettings() {
  prefs.begin("fish", false);
  prefs.putUChar("fishType",  fishType);
  prefs.putBool("useTime",    useTime);
  prefs.putBool("useSpawn",   useSpawn);
  prefs.putBool("useMoon",    useMoon);
  prefs.putUChar("waterType", waterType);
  prefs.putUChar("tzMode",    tzMode);
  prefs.end();
}




bool loadState() {
  // Завантажуємо тільки налаштування — вони зберігаються завжди і не скидаються при вимкненні
  prefs.begin("fish", true);
  fishType  = prefs.getUChar("fishType", 0);
  useTime   = prefs.getBool("useTime",   true);
  useSpawn  = prefs.getBool("useSpawn",  true);
  useMoon   = prefs.getBool("useMoon",   true);
  waterType = prefs.getUChar("waterType", 0);
  tzMode    = prefs.getUChar("tzMode",   0);
  prefs.end();
  return false; // масиви не відновлюються — завжди свіжий старт
}



// ===================== WiFi МЕНЕДЖЕР ========================

#define MAX_WIFI_NETS  10
#define FORECAST_HOURS 192  // 1 день назад + 7 днів вперед

struct WifiNet {
  char ssid[33];
  char pass[65];
};

// Збережені мережі
WifiNet wifiNets[MAX_WIFI_NETS];
byte    wifiNetCount = 0;
bool    staConnected = false;   // підключені до роутера
uint32_t staRetryMs  = 0;       // таймер повторного підключення

// Локація
char cityName[33]  = "";
float cityLat      = 0.0f;
float cityLon      = 0.0f;

// Якщо порожній — використовується тільки Open-Meteo

// Прогноз — погодинно 7 днів
struct ForecastHour {
  int8_t  temp;       // температура °C
  uint16_t pressure;  // тиск мм рт.ст.
  uint8_t  pop;       // імовірність дощу 0-100
  uint8_t  wid;       // weather code (WMO)
  uint8_t  hum;       // відносна вологість повітря 0-100
  uint8_t  wind;      // швидкість вітру м/с (0-255, але реально 0-50)
  uint8_t  cloud;     // хмарність 0-100
  uint16_t windDir;   // напрямок вітру, градуси звідки дме
};

ForecastHour forecast[FORECAST_HOURS];
uint32_t forecastTimestamp = 0;  // unix час першого запису прогнозу
bool     forecastValid     = false;
volatile bool forecastSyncing = false;
bool     needFetchForecast = false;  // прапорець: виконати fetchForecast при першій нагоді в loop()
TaskHandle_t fetchTaskHandle = NULL;  // FreeRTOS таск для fetchForecast
volatile bool manualSyncDone = false; // результат ручної синхронізації (/syncstatus)
volatile bool manualSyncOk   = false;
volatile bool sunSyncDone    = false; // результат синхронізації sunrise (/sunsyncstatus)
volatile bool sunSyncOk      = false;
volatile bool sunSyncing     = false; // йде синхронізація sunrise

// Кешований денний прогноз (оновлюється раз на добу, не зникає між оновленнями)
// Зберігає дані для кожної години дня (0-23) на поточний день
struct DailyForecastCache {
  bool     valid;         // чи заповнено кеш
  uint32_t dayTimestamp;  // unix-час початку дня (00:00 UTC місцевого часу)
  int8_t   temp[24];      // температура по годинах 00-23
  uint16_t pressure[24];  // тиск по годинах
  uint8_t  pop[24];       // шанс дощу
  uint8_t  wid[24];       // weather code
  uint8_t  hum[24];       // вологість
  uint8_t  wind[24];      // вітер
  uint8_t  cloud[24];     // хмарність
  uint16_t windDir[24];   // напрямок вітру
  // Сонячні події на 7 днів (локальний час, хвилини від 00:00; 0xFFFF = немає даних)
  // [0] = сьогодні, [1] = завтра, ..., [6] = +6 днів
  uint16_t sunriseMin[7];
  uint16_t sunsetMin[7];
  uint32_t sunDayTs[7];  // unix-час початку дня (для перевірки актуальності)
};
DailyForecastCache dayCache = {
  false, 0, {}, {}, {}, {}, {}, {}, {}, {},
  {0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF},
  {0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF},
  {0,0,0,0,0,0,0}
};

// Попередня зовнішня температура для градієнту (Фактор 5)
float prevOutdoorTemp  = -999.0f;
uint32_t prevTempTime  = 0;

// === REAL-TIME дані поточної погоди (з Open-Meteo current, оновлюється кожні 30 хв) ===
// Це "живий" зріз, незалежний від погодинного прогнозу.
// Якщо realtimeValid=false — calcFishScore() просто ігнорує ці дані.
struct RealtimeWeather {
  bool     valid;           // чи є дані
  uint32_t fetchedAt;       // millis() коли отримано
  float    precipitation;   // опади мм/год (>0 = дощ іде ЗАРАЗ)
  uint8_t  weatherCode;     // WMO weather code прямо зараз
  float    temperature;     // температура зараз °C
  float    windSpeed;       // вітер м/с зараз
  uint16_t windDir;         // напрямок вітру зараз
  uint8_t  humidity;        // вологість % зараз
  float    surfacePressure; // тиск мм рт.ст. зараз (surface_pressure → мм)
};
RealtimeWeather rtWeather = {false, 0, 0.0f, 0, 0.0f, 0.0f, 0, 0, 0.0f};

// Завантаження мереж з NVS
void loadWifiNets() {
  prefs.begin("wifi", true);
  wifiNetCount = prefs.getUChar("count", 0);
  if (wifiNetCount > MAX_WIFI_NETS) wifiNetCount = MAX_WIFI_NETS;
  prefs.getBytes("nets", wifiNets, sizeof(WifiNet) * wifiNetCount);
  prefs.getString("city", cityName, sizeof(cityName));
  cityLat = prefs.getFloat("lat", 0.0f);
  cityLon = prefs.getFloat("lon", 0.0f);
  // Два слоти координат
  coordLatA = prefs.getFloat("latA", cityLat);
  coordLonA = prefs.getFloat("lonA", cityLon);
  coordLatB = prefs.getFloat("latB", 0.0f);
  coordLonB = prefs.getFloat("lonB", 0.0f);
  coordActiveSlot = prefs.getUChar("coordSlot", 0);
  prefs.end();
}

void saveWifiNets() {
  prefs.begin("wifi", false);
  prefs.putUChar("count", wifiNetCount);
  prefs.putBytes("nets",  wifiNets, sizeof(WifiNet) * wifiNetCount);
  prefs.putString("city", cityName);
  prefs.putFloat("lat",   cityLat);
  prefs.putFloat("lon",   cityLon);
  // Два слоти координат
  prefs.putFloat("latA",  coordLatA); prefs.putFloat("lonA", coordLonA);
  prefs.putFloat("latB",  coordLatB); prefs.putFloat("lonB", coordLonB);
  prefs.putUChar("coordSlot", coordActiveSlot);
  prefs.end();
}

void saveSunTimes() {
  if (dayCache.sunriseMin[0] == 0xFFFF) return;
  prefs.begin("fish", false);
  prefs.putBytes("sunRise7", dayCache.sunriseMin, sizeof(dayCache.sunriseMin));
  prefs.putBytes("sunSet7",  dayCache.sunsetMin,  sizeof(dayCache.sunsetMin));
  prefs.putBytes("sunTs7",   dayCache.sunDayTs,   sizeof(dayCache.sunDayTs));
  prefs.end();
}

void loadSunTimes() {
  prefs.begin("fish", true);
  if (prefs.getBytesLength("sunRise7") == sizeof(dayCache.sunriseMin)) {
    prefs.getBytes("sunRise7", dayCache.sunriseMin, sizeof(dayCache.sunriseMin));
    prefs.getBytes("sunSet7",  dayCache.sunsetMin,  sizeof(dayCache.sunsetMin));
    prefs.getBytes("sunTs7",   dayCache.sunDayTs,   sizeof(dayCache.sunDayTs));
    // Зсуваємо масив якщо [0] не сьогодні
    int32_t utcOff = getUtcOffset();
    time_t localNow = (time_t)((int64_t)rtc.now().unixtime());
    struct tm tmNow; localtime_r(&localNow, &tmNow);
    tmNow.tm_hour = 0; tmNow.tm_min = 0; tmNow.tm_sec = 0;
    uint32_t todayStart = (uint32_t)((int64_t)mktime(&tmNow) - utcOff);
    int shift = -1;
    for (int i = 0; i < 7; i++) {
      if (dayCache.sunDayTs[i] == todayStart) { shift = i; break; }
    }
    if (shift > 0) {
      for (int i = 0; i < 7 - shift; i++) {
        dayCache.sunriseMin[i] = dayCache.sunriseMin[i + shift];
        dayCache.sunsetMin[i]  = dayCache.sunsetMin[i + shift];
        dayCache.sunDayTs[i]   = dayCache.sunDayTs[i + shift];
      }
      for (int i = 7 - shift; i < 7; i++) {
        dayCache.sunriseMin[i] = 0xFFFF;
        dayCache.sunsetMin[i]  = 0xFFFF;
        dayCache.sunDayTs[i]   = 0;
      }
    } else if (shift < 0) {
      for (int i = 0; i < 7; i++) {
        dayCache.sunriseMin[i] = 0xFFFF;
        dayCache.sunsetMin[i]  = 0xFFFF;
        dayCache.sunDayTs[i]   = 0;
      }
    }
  }
  prefs.end();
}

void saveForecast() {
  prefs.begin("fcast", false);
  prefs.putUChar("ver", 4);
  prefs.putUInt("ts",    forecastTimestamp);
  prefs.putBool("valid", forecastValid);
  prefs.putBytes("data", forecast, sizeof(forecast));
  prefs.end();
}

void loadForecast() {
  prefs.begin("fcast", true);
  byte ver = prefs.getUChar("ver", 0);
  forecastTimestamp = prefs.getUInt("ts",    0);
  forecastValid     = prefs.getBool("valid", false);
  if (ver == 4) {
    prefs.getBytes("data", forecast, sizeof(forecast));
  } else {
    // Стара версія або версія 3 (зі старим полем precise) — розмір структури інший, скидаємо
    forecastTimestamp = 0;
    forecastValid = false;
    memset(forecast, 0, sizeof(forecast));
  }
  prefs.end();

  // Захист від застарілого прогнозу (> 8 діб): якщо forecastTimestamp дуже старий,
  // всі реальні дані вже прокручені і масив буде нулями, але forecastValid=true.
  // Це призводить до показу нульового прогнозу. Скидаємо.
  if (forecastValid && forecastTimestamp > 0) {
    uint32_t nowTs = (uint32_t)time(NULL);
    // Якщо NTP ще не синхронізований (time < 2020), пропускаємо перевірку
    if (nowTs > 1577836800UL) { // 2020-01-01
      int32_t ageHours = (int32_t)((nowTs - forecastTimestamp) / 3600);
      if (ageHours >= FORECAST_HOURS) {
        forecastValid = false;
        forecastTimestamp = 0;
        memset(forecast, 0, sizeof(forecast));
        Serial.println("loadForecast: stale data (>8 days), cleared");
      }
    }
  }
}

// Оновлює денний кеш прогнозу.
// Кеш тримає прогноз по 24 годинах ПОТОЧНОГО дня і НЕ оновлюється протягом дня —
// тільки при переході на новий день або після завантаження нового прогнозу.
// Кеш живе до кінця масиву forecast[] (FORECAST_HOURS=192 год = 8 діб від завантаження).
// При переході доби кеш автоматично інвалідується навіть якщо forecastValid=false.
void updateDayCache() {
  // БАГ-ВИПРАВЛЕННЯ: якщо прогноз вичерпано (forecastValid=false), але кеш ще valid —
  // перевіряємо чи не настав новий день. Якщо день змінився — скидаємо застарілий кеш.
  if (!forecastValid || forecastTimestamp == 0) {
    if (dayCache.valid) {
      int32_t utcOff = getUtcOffset();
      time_t nowUtc = (time_t)rtc.now().unixtime() - utcOff;
      time_t localNow = nowUtc + utcOff;
      struct tm todayTm;
      localtime_r(&localNow, &todayTm);
      todayTm.tm_hour = 0; todayTm.tm_min = 0; todayTm.tm_sec = 0;
      time_t todayLocalMidnight = mktime(&todayTm);
      uint32_t todayStartUtc = (uint32_t)(todayLocalMidnight - utcOff);
      if (dayCache.dayTimestamp != todayStartUtc) {
        dayCache.valid = false;
        Serial.println("DayCache: new day detected without forecast, cache cleared");
      }
    }
    return;
  }

  int32_t utcOff = getUtcOffset();
  time_t nowUtc;
  struct tm ti;
  if (getLocalTime(&ti, 0)) {
    ti.tm_isdst = 0;
    nowUtc = mktime(&ti) - utcOff;
  } else {
    nowUtc = (time_t)rtc.now().unixtime() - utcOff;
  }

  // Визначаємо початок поточного дня в UTC (00:00 місцевого часу = UTC - utcOff)
  time_t localNow = nowUtc + utcOff;
  struct tm todayTm;
  localtime_r(&localNow, &todayTm);
  todayTm.tm_hour = 0; todayTm.tm_min = 0; todayTm.tm_sec = 0;
  time_t todayLocalMidnight = mktime(&todayTm);
  uint32_t todayStartUtc = (uint32_t)(todayLocalMidnight - utcOff);

  // Якщо кеш вже для сьогодні — не оновлюємо (прогноз залишається незмінним)
  if (dayCache.valid && dayCache.dayTimestamp == todayStartUtc) return;

  // Знаходимо індекс 00:00 сьогоднішнього дня в масиві прогнозу
  if (nowUtc < (time_t)forecastTimestamp) {
    // Час ще не синхронізовано
    return;
  }
  int startIdx = (int)((todayStartUtc - forecastTimestamp) / 3600);
  if (startIdx < 0) startIdx = 0;
  if (startIdx >= FORECAST_HOURS) {
    // Сьогоднішній день поза масивом — кеш застарів
    dayCache.valid = false;
    return;
  }

  // Заповнюємо кеш 24 годинами
  dayCache.dayTimestamp = todayStartUtc;
  for (int h = 0; h < 24; h++) {
    int idx = startIdx + h;
    if (idx < FORECAST_HOURS && forecast[idx].pressure > 0) {
      dayCache.temp[h]     = forecast[idx].temp;
      dayCache.pressure[h] = forecast[idx].pressure;
      dayCache.pop[h]      = forecast[idx].pop;
      dayCache.wid[h]      = forecast[idx].wid;
      dayCache.hum[h]      = forecast[idx].hum;
      dayCache.wind[h]     = forecast[idx].wind;
      dayCache.cloud[h]    = forecast[idx].cloud;
      dayCache.windDir[h]  = forecast[idx].windDir;
    } else if (h > 0) {
      // Якщо дані закінчились — протягуємо останній відомий годину
      dayCache.temp[h]     = dayCache.temp[h-1];
      dayCache.pressure[h] = dayCache.pressure[h-1];
      dayCache.pop[h]      = dayCache.pop[h-1];
      dayCache.wid[h]      = dayCache.wid[h-1];
      dayCache.hum[h]      = dayCache.hum[h-1];
      dayCache.wind[h]     = dayCache.wind[h-1];
      dayCache.cloud[h]    = dayCache.cloud[h-1];
      dayCache.windDir[h]  = dayCache.windDir[h-1];
    }
  }
  dayCache.valid = true;
  Serial.printf("DayCache updated for UTC day %u (startIdx=%d)\n", todayStartUtc, startIdx);
}

bool basePressureSet() {
  return SEA_PRESS_MM >= 680.0f && SEA_PRESS_MM <= 800.0f;
}

bool startupWarmup() {
  // true = ще не всі 6 зразків зібрано (неповна точність)
  // Кльов вже показується після 3 зразків (~30 хв), але банер висить до 6 (~60 хв)
  return pressureSampleCount < 6;
}

// true = ще збираємо дані, але попередній результат вже можна показати
bool startupPreliminary() {
  return pressureSampleCount >= 3 && pressureSampleCount < 6;
}

const char* seasonName(byte season) {
  switch (season) {
    case 1: return "Зима";
    case 2: return "Весна";
    case 3: return "Літо";
    case 4: return "Осінь";
    default: return "Невідомо";
  }
}

String seasonDisplayName() {
  byte fromSeason = 0, toSeason = 0;
  byte pct = getSeasonTransition(fromSeason, toSeason);
  if (pct == 0 || fromSeason == toSeason) return String(seasonName(getSeason()));
  return String(seasonName(fromSeason)) + "/" + String(seasonName(toSeason)) + " " + String(pct) + "%";
}

// ===================== НЕРЕСТ ================================
bool isSpawnPeriod() {
  byte mo = rtc.now().month();
  switch (fishType) {
    case 1: return (mo == 2 || mo == 3);
    case 2: return (mo >= 5 && mo <= 6);
    case 3: return (mo >= 5 && mo <= 7);
    case 4: return (mo >= 5 && mo <= 7);
    case 5: return (mo >= 5 && mo <= 6);
    default:return (mo >= 5 && mo <= 6);
  }
}

// Повертає: 0=не нерест, 1=початок, 2=пік, 3=кінець/після
// Нерест: фаза залежить від місяця + трохи від температури.
// Температура може зсунути фазу на ±1 крок:
//   якщо холодніше норми → пік запізнюється (початок → початок, пік→початок)
//   якщо тепліше норми   → нерест прискорюється (початок → пік швидше)
// Вага температури мінімальна (~10-15% впливу) — головне дата.
byte spawnPhase() {
  if (!useSpawn) return 0;
  byte mo = rtc.now().month();

  // Температура для нересту — тільки вулична.
  // Прогноз: найточніше. prevOutdoorTemp: попереднє вуличне. Без даних — не коригуємо.
  int idx0 = forecastCurrentIdx();
  bool hasTNow = false;
  float tNow = 15.0f; // нейтральне значення якщо немає даних
  if (forecastValid && idx0 >= 0) {
    tNow = (float)forecast[idx0].temp;
    hasTNow = true;
  } else if (prevOutdoorTemp > -99.0f) {
    tNow = prevOutdoorTemp;
    hasTNow = true;
  }
  // Базова фаза по місяцю (оголошено перед першим використанням)
  byte phase = 0;
  if (!hasTNow) return phase; // немає вуличної температури — повертаємо фазу тільки по місяцю (0=не нерест)

  switch (fishType) {
    case 1: // щука/окунь: нерест лютий-березень при T>1°C
      if (mo == 2) phase = 1;
      else if (mo == 3) phase = 2;
      else if (mo == 4) phase = 3;
      // Температурна корекція: нерест іде при T>1°C; якщо холодно — фаза назад
      if (phase == 2 && tNow < 2.0f) phase = 1;       // пік→початок якщо мороз
      if (phase == 1 && tNow > 5.0f) phase = 2;       // початок→пік якщо тепло
      break;
    case 2: // карась: травень-червень при T>16°C
      if (mo == 5) phase = 1;
      else if (mo == 6) phase = 2;
      else if (mo == 7) phase = 3;
      if (phase == 1 && tNow < 14.0f) phase = 0;      // ще не почався — холодно
      if (phase == 2 && tNow < 16.0f) phase = 1;      // пік→початок якщо прохолодно
      if (phase == 1 && tNow > 20.0f) phase = 2;      // початок→пік якщо дуже тепло
      break;
    case 3: // короп: травень-липень при T>18°C
      if (mo == 5) phase = 1;
      else if (mo == 6) phase = 2;
      else if (mo == 7) phase = 2;
      else if (mo == 8) phase = 3;
      if (phase == 1 && tNow < 16.0f) phase = 0;
      if (phase == 2 && tNow < 18.0f) phase = 1;
      if (phase == 1 && tNow > 22.0f) phase = 2;
      break;
    case 4: // карась+короп: середнє між ними
      if (mo == 5) phase = 1;
      else if (mo == 6) phase = 2;
      else if (mo == 7) phase = 2;
      else if (mo == 8) phase = 3;
      if (phase == 1 && tNow < 15.0f) phase = 0;
      if (phase == 2 && tNow < 17.0f) phase = 1;
      if (phase == 1 && tNow > 21.0f) phase = 2;
      break;
    default: // мирна вся: травень-червень при T>14°C
      if (mo == 5) phase = 1;
      else if (mo == 6) phase = 2;
      else if (mo == 7) phase = 3;
      if (phase == 1 && tNow < 13.0f) phase = 0;
      if (phase == 2 && tNow < 15.0f) phase = 1;
      if (phase == 1 && tNow > 19.0f) phase = 2;
      break;
  }
  return phase;
}

int spawnScoreAdjust() {
  if (!useSpawn) return 0;
  byte phase = spawnPhase();
  switch (phase) {
    case 1: // початок нересту — риба ще активна, але починає відволікатись
      return (fishType == 1) ? -5 : -8;
    case 2: // пік нересту — риба майже не клює
      return (fishType == 1) ? -12 : -18;
    case 3: // після нересту — відновлення, жор починається
      return (fishType == 1) ? 8 : 12;
    default:
      return 0;
  }
}
// ============================================================

float forecastAvgTemp(int start, int count) {
  if (!forecastValid || count <= 0) return NAN;
  if (start < 0 || start + count > FORECAST_HOURS) return NAN;
  float sum = 0.0f;
  int used = 0;
  for (int i = start; i < start + count; i++) {
    sum += forecast[i].temp;
    used++;
  }
  return used > 0 ? sum / used : NAN;
}

int tempTrendC() {
  int idx = forecastCurrentIdx();
  if (idx < 24 || idx + 24 > FORECAST_HOURS) return 0;
  float yesterday = forecastAvgTemp(idx - 24, 24);
  float today = forecastAvgTemp(idx, 24);
  if (isnan(yesterday) || isnan(today)) return 0;
  return (int)round(today - yesterday);
}

const char* windFromName(uint16_t deg) {
  deg %= 360;
  if (deg >= 338 || deg < 23) return "Північ";
  if (deg < 68)  return "Пн-Схід";
  if (deg < 113) return "Схід";
  if (deg < 158) return "Пд-Схід";
  if (deg < 203) return "Південь";
  if (deg < 248) return "Пд-Захід";
  if (deg < 293) return "Захід";
  return "Пн-Захід";
}

const char* windTargetShore(uint16_t deg) {
  deg %= 360;
  if (deg >= 338 || deg < 23) return "південний берег";
  if (deg < 68)  return "пд-зах. берег";
  if (deg < 113) return "західний берег";
  if (deg < 158) return "пн-зах. берег";
  if (deg < 203) return "північний берег";
  if (deg < 248) return "пн-сх. берег";
  if (deg < 293) return "східний берег";
  return "пд-сх. берег";
}

String comfortText() {
  int idx = forecastCurrentIdx();
  if (!forecastValid || idx < 0) return "...";

  // Шукаємо денний пік температури: максимум серед годин від поточного до кінця доби (до 22:00 місц.)
  // Пік -2°C = температура в яку риба вже активна (трохи перед максимумом прогрівання)
  // Якщо прогноз є у dayCache — беремо максимум по 24 годинах кешу
  int tPeak = -99;
  if (dayCache.valid) {
    for (int h = 0; h < 24; h++) {
      int tv = (int)dayCache.temp[h];
      if (tv > tPeak) tPeak = tv;
    }
  } else {
    // Запасний варіант — максимум по наступних 24 годинах від зараз
    for (int i = idx; i < idx + 24 && i < FORECAST_HOURS; i++) {
      int tv = (int)forecast[i].temp;
      if (tv > tPeak) tPeak = tv;
    }
  }
  if (tPeak == -99) return "...";

  // Комфортна температура = пік - 2°C (коли вода ще не перегріта максимально, риба активна)
  int t = tPeak - 2;

  const char* name;
  int lo, hi;
  switch (fishType) {
    case 1: name = "Хижак";  lo = 8;  hi = 20; break;
    case 2: name = "Карась"; lo = 16; hi = 26; break;
    case 3: name = "Короп";  lo = 18; hi = 28; break;
    case 4: name = "К+Кр";   lo = 17; hi = 27; break;
    default:name = "Мирна";  lo = 14; hi = 26; break;
  }

  // Текст: пік дня і чи потрапляє риба в комфорт
  String verdict;
  if      (t < lo - 3) verdict = "холодно, обмін речовин повільний";
  else if (t < lo)     verdict = "нижче комфорту (" + String(lo) + "…" + String(hi) + "°C)";
  else if (t <= hi)    verdict = "✓ комфортна зона (" + String(lo) + "…" + String(hi) + "°C)";
  else if (t <= hi+3)  verdict = "тепло, на межі комфорту";
  else                 verdict = "спекотно, риба пішла на глибину";

  return String(name) + ": пік ~" + String(tPeak) + "°C → " + String(t) + "°C — " + verdict;
}

String futureBiteText() {
  int idx = forecastCurrentIdx();
  // Показуємо прогноз навіть якщо deltaReady=false — прогноз завантажений і вже корисний
  if (!forecastValid || idx < 0 || idx + 3 >= FORECAST_HOURS) return "...";

  int pressure3h = (int)forecast[idx + 3].pressure - (int)forecast[idx].pressure;
  int trend = tempTrendC();
  uint8_t cloud3 = forecast[idx + 3].cloud;
  uint8_t wind3  = forecast[idx + 3].wind;
  uint8_t pop3   = forecast[idx + 3].pop;
  uint8_t hum3   = forecast[idx + 3].hum;
  float   temp3  = (float)forecast[idx + 3].temp;

  // Спочатку найгірші умови
  if (forecast[idx + 3].wid >= 95) return "Через 3 год: гроза — риба ховається.";
  if (pressure3h <= -3) return "Через 3 год: тиск падає, кльов погіршиться.";
  if (pressure3h >= 3)  return "Через 3 год: тиск різко росте, зачекайте стабілізації.";
  if (wind3 >= 9)        return "Через 3 год: сильний вітер — кльов слабкий.";
  // Позитивні сигнали
  if (pop3 > 70 && temp3 > 18) return "Через 3 год: дощ може активізувати рибу.";
  if (pressure3h == 0 && hum3 >= 65 && hum3 <= 82 && wind3 < 6)
    return "Через 3 год: стабільний тиск і комфортна вологість — добрий кльов.";
  if (trend >= 3 && getSeason() == 2) return "Через 3 год: потепління — добре для весняного кльову.";
  if (trend <= -3) return "Через 3 год: похолодання може загальмувати рибу.";
  if (cloud3 >= 60 && wind3 < 8) return "Через 3 год: хмарно — риба може вийти на мілину.";
  if (pressure3h == 0) return "Через 3 год: умови стабільні.";
  return "Через 3 год: умови без суттєвих змін.";
}

void resetRuntimePressureState() {
  delta = 0;
  deltaReady = false;
  dispRain = 0;
  pressureSampleCount = 0;
  memset(pressure_array, 0, sizeof(pressure_array));
  smoothedPress     = 0.0f;
  smoothedPressInit = false;
  adaptPress = dispPres;
  stableStartMs = 0;
  pressJumped = false;
  jumpMagnitudeMm = 0.0f;
  jumpStartMs = 0;
  jumpExtraHits = 0;
  lastAdaptDoneMs = 0;
  lastAdaptPress = dispPres;
  lastAdaptCreditMs = 0;
}

void factoryResetRuntime() {
  pressSlotA = 0.0f;
  pressSlotB = 0.0f;
  pressActiveSlot = 0;
  SEA_PRESS_MM = 0.0f;
  coordLatA = coordLonA = coordLatB = coordLonB = 0.0f;
  coordActiveSlot = 0;
  cityLat = cityLon = 0.0f;
  cityName[0] = '\0';
  wifiNetCount = 0;
  forecastValid = false;
  forecastTimestamp = 0;
  memset(wifiNets, 0, sizeof(wifiNets));
  memset(forecast, 0, sizeof(forecast));
  memset(tempHour, 0, sizeof(tempHour));
  memset(humHour, 0, sizeof(humHour));
  memset(tempDay, 0, sizeof(tempDay));
  memset(humDay, 0, sizeof(humDay));
  memset(pressHour, 0, sizeof(pressHour));
  memset(pressDay, 0, sizeof(pressDay));
  memset(fishHour, 0, sizeof(fishHour));
  fishType  = 0;
  useTime   = true;
  useSpawn  = true;
  useMoon   = true;
  waterType = 0;
  tzMode    = 0;
  dayCache = {
    false, 0, {}, {}, {}, {}, {}, {}, {}, {},
    {0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF},
    {0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF},
    {0,0,0,0,0,0,0}
  };
  resetRuntimePressureState();
}

// Геокодер — шукає координати міста через Open-Meteo geocoding API
bool geocodeCity(const char* city) {
  if (!staConnected) return false;
  if (httpMutex && xSemaphoreTake(httpMutex, pdMS_TO_TICKS(20000)) != pdTRUE) return false;
  HTTPClient http;
  char url[200];
  snprintf(url, sizeof(url),
    "http://geocoding-api.open-meteo.com/v1/search?name=%s&count=1&language=uk&format=json", city);
  http.begin(url);
  int code = http.GET();
  if (code != 200) { http.end(); if (httpMutex) xSemaphoreGive(httpMutex); return false; }
  JsonDocument doc;
  deserializeJson(doc, http.getStream());
  http.end();
  if (httpMutex) xSemaphoreGive(httpMutex);
  if (!doc["results"] || doc["results"].size() == 0) return false;
  cityLat = doc["results"][0]["latitude"].as<float>();
  cityLon = doc["results"][0]["longitude"].as<float>();
  return true;
}

// Завантаження прогнозу з Open-Meteo
// ===================== REAL-TIME ПОГОДА (Open-Meteo current) ========================
// Короткий запит кожні 30 хв: отримуємо реальний стан погоди прямо зараз.
// Дані: precipitation (чи іде дощ), weather_code, temp, wind, humidity, surface_pressure.
// Результат зберігається в rtWeather і використовується в calcFishScore().
bool fetchRealtimeWeather() {
  if (!staConnected || cityLat == 0.0f) return false;
  if (httpMutex && xSemaphoreTake(httpMutex, pdMS_TO_TICKS(20000)) != pdTRUE) return false;
  HTTPClient http;
  char url[320];
  snprintf(url, sizeof(url),
    "http://api.open-meteo.com/v1/forecast"
    "?latitude=%.4f&longitude=%.4f"
    "&current=precipitation,weather_code,temperature_2m,wind_speed_10m,wind_direction_10m,relative_humidity_2m,surface_pressure"
    "&timezone=auto",
    cityLat, cityLon);
  http.begin(url);
  http.setTimeout(8000);
  http.addHeader("Accept-Encoding", "identity");
  int code = http.GET();
  if (code != 200) {
    Serial.printf("[rtWeather] HTTP err: %d\n", code);
    http.end();
    if (httpMutex) xSemaphoreGive(httpMutex);
    return false;
  }
  String body = http.getString();
  http.end();
  if (httpMutex) xSemaphoreGive(httpMutex); // звільняємо mutex одразу після HTTP

  JsonDocument doc;
  DeserializationError err = deserializeJson(doc, body);
  body = String();
  if (err) {
    Serial.printf("[rtWeather] JSON err: %s\n", err.c_str());
    return false;
  }

  JsonObject cur = doc["current"];
  if (!cur) {
    Serial.println("[rtWeather] no current block");
    return false;
  }

  float precip   = cur["precipitation"].as<float>();
  uint8_t wcode  = (uint8_t)cur["weather_code"].as<int>();
  float temp     = cur["temperature_2m"].as<float>();
  float wind_kph = cur["wind_speed_10m"].as<float>();
  uint16_t wdir  = (uint16_t)constrain(cur["wind_direction_10m"].as<int>(), 0, 360);
  uint8_t  hum   = (uint8_t)constrain(cur["relative_humidity_2m"].as<int>(), 0, 100);
  float    presHpa = cur["surface_pressure"].as<float>();
  float    presMm  = presHpa * 0.750062f;

  rtWeather.valid           = true;
  rtWeather.fetchedAt       = millis();
  rtWeather.precipitation   = precip;
  rtWeather.weatherCode     = wcode;
  rtWeather.temperature     = temp;
  rtWeather.windSpeed       = wind_kph / 3.6f; // км/год → м/с
  rtWeather.windDir         = wdir;
  rtWeather.humidity        = hum;
  rtWeather.surfacePressure = presMm;

  Serial.printf("[rtWeather] precip=%.1fmm wcode=%d temp=%.1f wind=%.1fm/s pres=%.1fmm\n",
    precip, wcode, temp, rtWeather.windSpeed, presMm);

  // Коригуємо dispRain на основі реального стану:
  // Якщо дощ прямо зараз — підіймаємо мінімум до 60%
  // Якщо ясно (wcode<=2) і наш dispRain завищений — м'яко знижуємо
  if (precip > 0.5f) {
    dispRain = max((int)dispRain, 60);
    Serial.printf("[rtWeather] Дощ зараз! dispRain → %d%%\n", dispRain);
  } else if (wcode <= 2 && dispRain > 30) {
    dispRain = (int)(dispRain * 0.8f); // ясно — знижуємо завищений dispRain
  }

  return true;
}

bool fetchForecast() {
  if (!staConnected || cityLat == 0.0f) return false;
  forecastSyncing = true;
  if (httpMutex && xSemaphoreTake(httpMutex, pdMS_TO_TICKS(30000)) != pdTRUE) {
    forecastSyncing = false; return false;
  }
  HTTPClient http;
  char url[420];
  snprintf(url, sizeof(url),
    "http://api.open-meteo.com/v1/forecast"
    "?latitude=%.4f&longitude=%.4f"
    "&hourly=temperature_2m,surface_pressure,precipitation_probability,weather_code,relative_humidity_2m,wind_speed_10m,cloud_cover,wind_direction_10m"
    "&past_days=1&forecast_days=7&timezone=auto&timeformat=unixtime",
    cityLat, cityLon);
  http.begin(url);
  http.setTimeout(15000);  // збільшено з 10 до 15 сек
  http.addHeader("Accept-Encoding", "identity");  // без gzip — менше heap
  int code = http.GET();
  if (code != 200) {
    Serial.printf("Forecast HTTP err: %d\n", code);
    http.end(); if (httpMutex) xSemaphoreGive(httpMutex); forecastSyncing = false; return false;
  }

  // Читаємо у String — надійніше ніж потоковий парсинг при повільному WiFi
  String body = http.getString();
  http.end();
  if (httpMutex) xSemaphoreGive(httpMutex); // звільняємо mutex одразу після HTTP

  JsonDocument doc;
  DeserializationError err = deserializeJson(doc, body);
  body = String(); // звільняємо heap одразу
  if (err) {
    Serial.print("Forecast JSON err: "); Serial.println(err.c_str());
    forecastSyncing = false; return false;
  }

  JsonArray temps   = doc["hourly"]["temperature_2m"];
  JsonArray press   = doc["hourly"]["surface_pressure"];
  JsonArray pops    = doc["hourly"]["precipitation_probability"];
  JsonArray wids    = doc["hourly"]["weather_code"];
  JsonArray hums    = doc["hourly"]["relative_humidity_2m"];
  JsonArray winds   = doc["hourly"]["wind_speed_10m"];
  JsonArray clouds  = doc["hourly"]["cloud_cover"];
  JsonArray windDir = doc["hourly"]["wind_direction_10m"];

  if (!temps || temps.size() == 0) {
    Serial.println("Forecast: empty arrays");
    forecastSyncing = false; return false;
  }

  // Попереджаємо якщо API повернув менше годин ніж очікуємо.
  // Open-Meteo з ансамблем best_match+ecmwf_ifs+icon_seamless іноді обрізає хвіст.
  // Якщо temps.size() < 180 — хвіст масиву буде нулями (pressure==0).
  // updateDayCache() протягує останній відомий годину замість нулів, але краще знати.
  int gotHours = (int)temps.size();
  if (gotHours < 180) {
    Serial.printf("[WARN] Forecast: got only %d hours (expected %d). Tail will be zeroed.\n",
                  gotHours, FORECAST_HOURS);
  } else {
    Serial.printf("Forecast: got %d hours OK\n", gotHours);
  }
  // Обнуляємо весь масив перед заповненням — щоб хвіст не залишився з минулих даних
  memset(forecast, 0, sizeof(forecast));

  // Парсимо forecastTimestamp до заповнення масиву
  forecastTimestamp = 0;
  JsonArray times = doc["hourly"]["time"];
  int32_t utcOffset = doc["utc_offset_seconds"].as<int32_t>();
  if (utcOffset == 0) utcOffset = getUtcOffset();
  if (times && times.size() > 0) {
    uint32_t t0unix = times[0].as<uint32_t>();
    if (t0unix > 1000000000UL) {
      forecastTimestamp = t0unix;
    }
    Serial.printf("Forecast t0_unix=%u utcOff=%d rtcNow=%u\n",
      forecastTimestamp, utcOffset, rtc.now().unixtime());
  }
  if (forecastTimestamp == 0) forecastTimestamp = (uint32_t)((time_t)rtc.now().unixtime() - utcOffset);

  // Спочатку заповнюємо весь масив з Open-Meteo (precise=false)
  for (int i = 0; i < FORECAST_HOURS && i < (int)temps.size(); i++) {
    forecast[i].temp     = (int8_t)round(temps[i].as<float>());
    forecast[i].pressure = (uint16_t)round(press[i].as<float>() * 0.750062f);
    forecast[i].pop      = (uint8_t)pops[i].as<int>();
    forecast[i].wid      = (uint8_t)wids[i].as<int>();
    forecast[i].hum      = (uint8_t)constrain(hums[i].as<int>(), 0, 100);
    forecast[i].wind     = winds ? (uint8_t)constrain((int)(winds[i].as<float>() / 3.6f + 0.5f), 0, 255) : 0;
    forecast[i].cloud    = clouds ? (uint8_t)constrain(clouds[i].as<int>(), 0, 100) : 0;
    forecast[i].windDir  = windDir ? (uint16_t)constrain(windDir[i].as<int>(), 0, 360) : 0;
  }

  forecastValid     = true;
  forecastSyncing   = false;

  saveForecast();
  dayCache.valid = false;
  updateDayCache();
  Serial.println("Forecast updated OK");

  return true;
}

// Окремий запит sunrise/sunset на 7 днів — без models= (несумісно з daily у Open-Meteo).
// Може викликатись і незалежно (щодобове оновлення о 00:00, ручна синхронізація).
bool fetchSunTimes() {
  if (!staConnected || cityLat == 0.0f) return false;
  if (httpMutex && xSemaphoreTake(httpMutex, pdMS_TO_TICKS(20000)) != pdTRUE) {
    Serial.println("fetchSunTimes: mutex timeout");
    return false;
  }
  char sunUrl[256];
  snprintf(sunUrl, sizeof(sunUrl),
    "http://api.open-meteo.com/v1/forecast"
    "?latitude=%.4f&longitude=%.4f"
    "&daily=sunrise,sunset"
    "&forecast_days=7&timezone=auto&timeformat=unixtime",
    cityLat, cityLon);

  HTTPClient sunHttp;
  sunHttp.begin(sunUrl);
  sunHttp.setTimeout(8000);
  sunHttp.addHeader("Accept-Encoding", "identity");
  int sunCode = sunHttp.GET();
  bool ok = false;
  if (sunCode == 200) {
    String sunBody = sunHttp.getString();
    sunHttp.end();
    JsonDocument sunDoc;
    if (!deserializeJson(sunDoc, sunBody)) {
      JsonArray srArr = sunDoc["daily"]["sunrise"];
      JsonArray ssArr = sunDoc["daily"]["sunset"];
      JsonArray tsArr = sunDoc["daily"]["time"];
      int32_t utcOff  = getUtcOffset();
      int filled = 0;
      // Скидаємо масив
      for (int i = 0; i < 7; i++) {
        dayCache.sunriseMin[i] = 0xFFFF;
        dayCache.sunsetMin[i]  = 0xFFFF;
        dayCache.sunDayTs[i]   = 0;
      }
      int n = min((int)srArr.size(), 7);
      for (int i = 0; i < n; i++) {
        uint32_t srTs  = srArr[i].as<uint32_t>();
        uint32_t ssTs  = ssArr[i].as<uint32_t>();
        uint32_t dayTs = tsArr[i].as<uint32_t>(); // midnight local (unix)
        if (srTs == 0 || ssTs == 0) continue;
        uint32_t srLocal = (uint32_t)((int64_t)srTs + utcOff);
        uint32_t ssLocal = (uint32_t)((int64_t)ssTs + utcOff);
        // dayTs від Open-Meteo з timezone=auto — вже local midnight unix
        // sunDayTs[i] = UTC початок дня = dayTs - utcOff
        dayCache.sunriseMin[i] = (uint16_t)((srLocal % 86400) / 60);
        dayCache.sunsetMin[i]  = (uint16_t)((ssLocal % 86400) / 60);
        dayCache.sunDayTs[i]   = (uint32_t)((int64_t)dayTs - utcOff);
        // Відладка: показуємо що записалось
        uint32_t localMidDbg = (uint32_t)((int64_t)dayCache.sunDayTs[i] + 2*utcOff);
        time_t lmDbg = (time_t)localMidDbg;
        struct tm tmDbg; gmtime_r(&lmDbg, &tmDbg);
        Serial.printf("sunTimes[%d]: date=%04d-%02d-%02d rise=%d set=%d dayTs=%lu sunDayTs=%lu\n",
          i, tmDbg.tm_year+1900, tmDbg.tm_mon+1, tmDbg.tm_mday,
          dayCache.sunriseMin[i], dayCache.sunsetMin[i],
          (unsigned long)dayTs, (unsigned long)dayCache.sunDayTs[i]);
        filled++;
      }
      if (filled > 0) {
        Serial.printf("Sun 7d: today %02d:%02d/%02d:%02d .. +%dd\n",
          dayCache.sunriseMin[0]/60, dayCache.sunriseMin[0]%60,
          dayCache.sunsetMin[0]/60,  dayCache.sunsetMin[0]%60, filled-1);
        saveSunTimes();
        ok = true;
      }
    } else {
      Serial.println("Sunrise JSON parse err");
    }
  } else {
    Serial.printf("Sunrise HTTP err: %d\n", sunCode);
    sunHttp.end();
  }
  if (httpMutex) xSemaphoreGive(httpMutex);
  return ok;
}

// (fetchBasePress видалено — базовий тиск тільки вручну)

// Базовий тиск задається тільки вручну через веб-інтерфейс (слоти A і B)
// Але є кнопка-підказка: завантажує середнє за 7 днів з Open-Meteo і підставляє в поле.
// Зберігати чи ні — вирішує юзер сам.
float fetchBasePress() {
  if (!staConnected || cityLat == 0.0f) return 0.0f;
  if (httpMutex && xSemaphoreTake(httpMutex, pdMS_TO_TICKS(20000)) != pdTRUE) return 0.0f;
  HTTPClient http;
  char url[300];
  snprintf(url, sizeof(url),
    "http://api.open-meteo.com/v1/forecast"
    "?latitude=%.4f&longitude=%.4f"
    "&hourly=surface_pressure&past_days=7&forecast_days=0&timeformat=unixtime",
    cityLat, cityLon);
  http.begin(url);
  http.setTimeout(12000);
  http.addHeader("Accept-Encoding", "identity");
  int code = http.GET();
  if (code != 200) { http.end(); if (httpMutex) xSemaphoreGive(httpMutex); return 0.0f; }
  String body = http.getString();
  http.end();
  if (httpMutex) xSemaphoreGive(httpMutex);
  JsonDocument doc;
  if (deserializeJson(doc, body)) return 0.0f;
  body = String();
  JsonArray press = doc["hourly"]["surface_pressure"];
  if (!press || press.size() == 0) return 0.0f;
  double sum = 0; int cnt = 0;
  for (int i = 0; i < (int)press.size() && i < 168; i++) {
    float p = press[i].as<float>();
    if (p > 800 && p < 1100) { sum += p; cnt++; }
  }
  if (cnt == 0) return 0.0f;
  float avgMm = (float)(sum / cnt) * 0.750062f;
  Serial.printf("fetchBasePress: %.1f мм (avg %d годин)\n", avgMm, cnt);
  return avgMm;
}

// Поточний індекс в масиві прогнозу (яка година зараз)
int forecastCurrentIdx() {
  if (!forecastValid || forecastTimestamp == 0) return -1;
  // forecastTimestamp — UTC unix початку масиву
  int32_t utcOff = getUtcOffset();
  time_t nowUtc;
  struct tm ti;
  if (getLocalTime(&ti, 0)) {
    // getLocalTime повертає локальний час (UTC+utcOff при configTime(utcOff,...))
    ti.tm_isdst = 0;
    nowUtc = mktime(&ti) - utcOff;
  } else {
    // RTC зберігає локальний час → відніmaємо offset
    nowUtc = (time_t)rtc.now().unixtime() - utcOff;
  }
  // Захист від від'ємного elapsed (якщо час ще не синхронізовано)
  if (nowUtc < (time_t)forecastTimestamp) return 0;
  int idx = (int)((nowUtc - (time_t)forecastTimestamp) / 3600);
  if (idx >= FORECAST_HOURS) return -1;
  return idx;
}

// NTP синхронізація RTC
void syncNTP() {
  Serial.println("NTP sync...");
  // Використовуємо динамічний UTC-офсет (авто DST або фіксований з налаштувань)
  int32_t utcOff = getUtcOffset();
  configTime(utcOff, 0, "pool.ntp.org", "time.google.com", "time.cloudflare.com");
  struct tm ti;
  // Чекаємо максимум 5 сек
  uint32_t start = millis();
  while (!getLocalTime(&ti, 100) && millis() - start < 5000) delay(100);
  if (getLocalTime(&ti, 100)) {
    // Синхронізуємо RTC (зберігаємо локальний час)
    rtc.adjust(DateTime(ti.tm_year + 1900, ti.tm_mon + 1, ti.tm_mday,
                        ti.tm_hour, ti.tm_min, ti.tm_sec));
    Serial.printf("NTP OK: %04d-%02d-%02d %02d:%02d:%02d (UTC%+d)\n",
      ti.tm_year+1900, ti.tm_mon+1, ti.tm_mday, ti.tm_hour, ti.tm_min, ti.tm_sec,
      (int)(utcOff/3600));
    hrs  = ti.tm_hour;
    mins = ti.tm_min;
    secs = ti.tm_sec;
  } else {
    Serial.println("NTP failed");
  }
}

// Підключення до WiFi — перебираємо мережі без блокуючого сканування
// Просто по черзі починаємо WiFi.begin(); статус перевіряємо в wifiSyncTick()
static byte wifiConnectIdx = 0;       // яку мережу зараз пробуємо
static uint32_t wifiConnectStart = 0; // коли почали спробу
static bool wifiConnecting = false;   // зараз йде спроба

void tryConnectWifi() {
  if (wifiNetCount == 0) return;
  wifiConnectIdx = 0;
  // Якщо AP вже активна — залишаємо AP+STA, інакше просто STA
  WiFi.mode(apActive ? WIFI_AP_STA : WIFI_STA);
  WiFi.begin(wifiNets[0].ssid, wifiNets[0].pass);
  wifiConnectStart = millis();
  wifiConnecting = true;
  Serial.print("WiFi try: "); Serial.println(wifiNets[0].ssid);
}

// Фонова задача WiFi + синхронізація
void wifiSyncTick() {
  uint32_t ms = millis();

  // --- Неблокуючий коннект: перевіряємо результат поточної спроби ---
  if (wifiConnecting) {
    wl_status_t st = WiFi.status();
    if (st == WL_CONNECTED) {
      wifiConnecting = false;
      if (!staConnected) {
        staConnected = true;
        Serial.print("WiFi connected: "); Serial.println(WiFi.SSID());
        Serial.print("IP: "); Serial.println(WiFi.localIP());
        syncNTP();  // синхронізуємо RTC відразу після підключення
        // Якщо AP не активна — запускаємо веб-сервер через STA
        if (!staWebActive) {
          setupWebServer();
          webServer.begin();
          staWebActive = true;
          Serial.print("WebServer via STA IP: "); Serial.println(WiFi.localIP());
        }
        // Якщо AP активна але не вручну — вимикаємо, тепер є роутер
        if (apActive && !apManual) {
          apActive = false;
          WiFi.softAPdisconnect(true);
          WiFi.mode(WIFI_STA);
          Serial.println("Auto-AP disabled, STA connected");
        }
        if (mode == 0) drawApBadge();
        // Якщо прогноз старий (>12 год) або відсутній — ставимо прапорець.
        // fetchForecast() не викликаємо тут бо він блокуючий (до 15 сек) —
        // loop() виконає його окремо щоб не зависати.
        // forecastTimestamp — UTC, RTC зберігає local → відніmaємо offset
        uint32_t nowTs = (uint32_t)((time_t)rtc.now().unixtime() - getUtcOffset());
        if (cityLat != 0.0f && (!forecastValid || (nowTs - forecastTimestamp) > 12*3600)) {
          needFetchForecast = true;
        }
        // Автоматично синхронізуємо sunrise якщо даних немає або вони застарілі (> 1 доба)
        if (cityLat != 0.0f && !sunSyncing && fetchTaskHandle == NULL) {
          bool sunMissing = (dayCache.sunriseMin[0] == 0xFFFF);
          bool sunStale   = (dayCache.sunDayTs[0] != 0 &&
                             (nowTs - dayCache.sunDayTs[0]) > 24*3600UL);
          if (sunMissing || sunStale) {
            sunSyncing = true; sunSyncDone = false; sunSyncOk = false;
            xTaskCreatePinnedToCore([](void*){
              bool r = fetchSunTimes();
              sunSyncOk = r; sunSyncDone = true; sunSyncing = false;
              vTaskDelete(NULL);
            }, "sunAutoSync", 6144, NULL, 1, NULL, 0);
            Serial.println("Auto sunrise sync triggered on WiFi connect");
          }
        }
      }
    } else if (ms - wifiConnectStart > 10000) {
      // Спроба для поточної мережі вичерпана — пробуємо наступну
      wifiConnectIdx++;
      if (wifiConnectIdx < wifiNetCount) {
        WiFi.begin(wifiNets[wifiConnectIdx].ssid, wifiNets[wifiConnectIdx].pass);
        wifiConnectStart = ms;
        Serial.print("WiFi try: "); Serial.println(wifiNets[wifiConnectIdx].ssid);
      } else {
        wifiConnecting = false;
        Serial.println("WiFi: all nets failed");
        // Якщо нічого не вийшло і AP не активна — продовжуємо без WiFi
      }
    }
    // поки йде спроба — обробляємо клієнтів (якщо сервер вже запущено)
    if (apActive || staWebActive) webServer.handleClient();
    return;
  }

  // --- Обробка веб-клієнтів ---
  if (apActive || staWebActive) webServer.handleClient();

  // --- Перевіряємо підключення кожні 30 сек ---
  static uint32_t checkMs = 0;
  static uint8_t disconnectCount = 0;  // гістерезис відключення
  if (ms - checkMs > 30000) {
    checkMs = ms;
    bool wasConnected = staConnected;
    bool nowWifiOk = (WiFi.status() == WL_CONNECTED);
    if (nowWifiOk) {
      disconnectCount = 0;
      staConnected = true;
    } else {
      disconnectCount++;
    }
    // Вважаємо відключеним тільки якщо 2 перевірки поспіль не підключені (60 сек)
    if (disconnectCount >= 2) {
      disconnectCount = 0;
      staConnected = false;
    }
    if (staConnected != wasConnected) {
      if (mode == 0) drawApBadge();
      if (!staConnected) {
        staWebActive = false;
        webServer.stop();
        if (wifiNetCount > 0) {
          WiFi.mode(apActive ? WIFI_AP_STA : WIFI_STA);
          tryConnectWifi();
        }
      } else {
        // Відновили підключення
        // Якщо AP не вмикали вручну — вимикаємо її (маємо роутер)
        if (apActive && !apManual) {
          apActive = false;
          WiFi.softAPdisconnect(true);
          WiFi.mode(WIFI_STA);
          Serial.println("Auto-AP disabled on STA reconnect");
        }
        if (!staWebActive) {
          setupWebServer();
          webServer.begin();
          staWebActive = true;
          Serial.print("WebServer via STA IP: "); Serial.println(WiFi.localIP());
        }
      }
    }
  }

  // --- Відкладений fetchForecast у FreeRTOS таску (не блокує loop) ---
  // Захист від deadlock: якщо forecastSyncing висить > 30 сек (таск впав) — скидаємо прапорець
  static uint32_t forecastSyncStartMs = 0;
  if (forecastSyncing && forecastSyncStartMs == 0) forecastSyncStartMs = ms;
  if (forecastSyncing && ms - forecastSyncStartMs > 30000UL) {
    forecastSyncing = false;
    fetchTaskHandle = NULL;
    forecastSyncStartMs = 0;
    Serial.println("[WARN] forecastSyncing watchdog: reset deadlock");
  }
  if (!forecastSyncing) forecastSyncStartMs = 0;

  if (needFetchForecast && staConnected && !forecastSyncing && fetchTaskHandle == NULL) {
    needFetchForecast = false;
    xTaskCreatePinnedToCore([](void*){
      fetchForecast();
      fetchTaskHandle = NULL;
      vTaskDelete(NULL);
    }, "fetchFC", 8192, NULL, 1, &fetchTaskHandle, 0); // ядро 0 — не конкурує з WiFi/webServer на ядрі 1
  }

  // --- Щогодинна NTP синхронізація RTC ---
  // Якщо є інтернет — раз на годину звіряємо і виправляємо час
  static uint32_t ntpSyncMs = 0;
  if (staConnected && ms - ntpSyncMs >= 3600UL * 1000) {
    ntpSyncMs = ms;
    syncNTP();
    updateDayCache(); // при зміні дня оновлюємо денний кеш
    Serial.println("Hourly NTP sync done");
  }

  // --- Оновлення прогнозу кожні 4 год (00:00, 04:00, 08:00, 12:00, 16:00, 20:00) ---
  // lastFetchHour зберігає годину яку вже обробили. Скидається тільки коли година змінилась,
  // тому жодних повторних fetch в межах тієї ж хвилини немає, але і втраченого фетчу теж немає.
  static byte lastFetchHour = 255;
  static byte lastKnownHour = 255; // для відстеження зміни години
  // Якщо година змінилась — знімаємо блокування щоб нова 4-годинна точка могла спрацювати
  if (lastKnownHour != (byte)hrs) {
    lastKnownHour = (byte)hrs;
    if (lastFetchHour != (byte)hrs) lastFetchHour = 255; // нова година — дозволяємо перевірку
  }
  if (staConnected && (hrs % 4 == 0) && mins == 0 && lastFetchHour != hrs) {
    lastFetchHour = hrs;
    if (fetchTaskHandle == NULL && !forecastSyncing) {
      xTaskCreatePinnedToCore([](void*){
        fetchForecast();
        fetchTaskHandle = NULL;
        vTaskDelete(NULL);
      }, "fetchFC", 8192, NULL, 1, &fetchTaskHandle, 0); // ядро 0
    }
  }

  // --- Перевірка поточної погоди кожні 30 хв (Open-Meteo current) ---
  static uint32_t rainCheckMs = 0;
  static bool rainCheckTaskBusy = false;
  if (staConnected && cityLat != 0.0f && !rainCheckTaskBusy && ms - rainCheckMs >= 30UL * 60 * 1000) {
    rainCheckMs = ms;
    rainCheckTaskBusy = true;
    // Запускаємо в окремому таску щоб не блокувати loop()
    xTaskCreatePinnedToCore([](void* p){
      bool* busy = (bool*)p;
      fetchRealtimeWeather();
      *busy = false;
      vTaskDelete(NULL);
    }, "rtWeather", 6144, &rainCheckTaskBusy, 1, NULL, 0);
  }

  // --- Прокручуємо масив прогнозу раз на годину (видаляємо минулі години) ---
  static uint32_t forecastScrollMs = 0;
  if (forecastValid && forecastTimestamp > 0 && ms - forecastScrollMs >= 3600UL * 1000) {
    forecastScrollMs = ms;

    // forecastTimestamp — UTC, rtc.now() — локальний → відніmaємо поточний UTC-offset
    time_t nowUtc;
    struct tm ti;
    int32_t utcOff2 = getUtcOffset();
    if (getLocalTime(&ti, 0)) {
      ti.tm_isdst = 0;
      nowUtc = mktime(&ti) - utcOff2;
    } else {
      nowUtc = (time_t)rtc.now().unixtime() - utcOff2;
    }

    if (nowUtc < (time_t)forecastTimestamp) {
      // Час ще не синхронізовано — нічого не робимо
    } else {
      int elapsed = (int)((nowUtc - (time_t)forecastTimestamp) / 3600);
      // Якщо elapsed >= FORECAST_HOURS — прогноз повністю вичерпано
      if (elapsed >= FORECAST_HOURS) {
        // Прогноз повністю вичерпано — але денний кеш ЗАЛИШАЄМО (там є дані поточного дня)
        forecastValid = false;
        forecastTimestamp = 0;
        Serial.println("Forecast exhausted, standalone mode (day cache still valid)");
      } else if (elapsed > 0) {
        // ВИПРАВЛЕННЯ БАГА З НУЛЯМИ:
        // Якщо пристрій був вимкнений кілька днів (elapsed може бути > 24, навіть > 48),
        // НЕ обмежуємо elapsed — зрушуємо рівно настільки скільки пройшло часу.
        // Це гарантує що forecastTimestamp завжди відповідає forecast[0].
        // Кінець масиву після memmove буде заповнений нулями (pressure==0),
        // але updateDayCache() перевіряє pressure>0 і використовує протягування —
        // тому на дисплеї нулів не буде.
        memmove(forecast, forecast + elapsed,
                (FORECAST_HOURS - elapsed) * sizeof(ForecastHour));
        memset(forecast + FORECAST_HOURS - elapsed, 0,
               elapsed * sizeof(ForecastHour));
        forecastTimestamp += (uint32_t)elapsed * 3600;
        Serial.printf("Forecast scrolled %d h, %d remain valid\n",
                      elapsed, FORECAST_HOURS - elapsed);
        // Оновлюємо денний кеш якщо настав новий день
        updateDayCache();
      }
    }
  }
}


// Яскравість
byte currentLcdBright = LCD_BRIGHT_MAX;
byte currentLedBright = LED_BRIGHT_MAX;
uint32_t sensorsTimer_ms   = 0;
uint32_t drawTimer_ms      = 0;
uint32_t clockTimer_ms     = 0;
uint32_t hourPlotTimer_ms  = 0;
uint32_t dayPlotTimer_ms   = 0;
uint32_t predictTimer_ms   = 0;
uint32_t brightTimer_ms    = 0;
uint32_t plotRedrawTimer_ms= 0;

// Кнопка
bool btnPrev = false;
uint32_t btnPressTime = 0;

// ------------------------- СИМВОЛИ -------------------------
// Графік
byte row8[8] = {0b11111,0b11111,0b11111,0b11111,0b11111,0b11111,0b11111,0b11111};
byte row7[8] = {0b00000,0b11111,0b11111,0b11111,0b11111,0b11111,0b11111,0b11111};
byte row6[8] = {0b00000,0b00000,0b11111,0b11111,0b11111,0b11111,0b11111,0b11111};
byte row5[8] = {0b00000,0b00000,0b00000,0b11111,0b11111,0b11111,0b11111,0b11111};
byte row4[8] = {0b00000,0b00000,0b00000,0b00000,0b11111,0b11111,0b11111,0b11111};
byte row3[8] = {0b00000,0b00000,0b00000,0b00000,0b00000,0b11111,0b11111,0b11111};
byte row2[8] = {0b00000,0b00000,0b00000,0b00000,0b00000,0b00000,0b11111,0b11111};
byte row1[8] = {0b00000,0b00000,0b00000,0b00000,0b00000,0b00000,0b00000,0b11111};

// Цифри годинника
uint8_t LT[8]  = {0b00111,0b01111,0b11111,0b11111,0b11111,0b11111,0b11111,0b11111};
uint8_t UB[8]  = {0b11111,0b11111,0b11111,0b00000,0b00000,0b00000,0b00000,0b00000};
uint8_t RT[8]  = {0b11100,0b11110,0b11111,0b11111,0b11111,0b11111,0b11111,0b11111};
uint8_t LL[8]  = {0b11111,0b11111,0b11111,0b11111,0b11111,0b11111,0b01111,0b00111};
uint8_t LB[8]  = {0b00000,0b00000,0b00000,0b00000,0b00000,0b11111,0b11111,0b11111};
uint8_t LR[8]  = {0b11111,0b11111,0b11111,0b11111,0b11111,0b11111,0b11110,0b11100};
uint8_t UMB[8] = {0b11111,0b11111,0b11111,0b00000,0b00000,0b00000,0b11111,0b11111};
uint8_t LMB[8] = {0b11111,0b00000,0b00000,0b00000,0b00000,0b11111,0b11111,0b11111};

#if (WEEK_LANG == 0)
static const char *dayNames[] = {"Sund","Mond","Tues","Wedn","Thur","Frid","Satu"};
#else
static const char *dayNames[] = {"NEDI","POND","VIVO","SERE","CHET","PIAT","SUBO"};
#endif

// ------------------------- LEDC ----------------------------
void setLcdBright(byte val) {
  ledcWrite(CH_BL, val);
}

void setRGB(byte r, byte g, byte b) {
  ledcWrite(CH_R, r);
  ledcWrite(CH_G, g);
  ledcWrite(CH_B, b);
}

// ------------------------- ЯСКРАВІСТЬ ----------------------
void checkBrightness() {
  // Усереднення 8 вимірів — прибираємо шум LDR
  static int ldrBuf[8];
  static byte ldrIdx = 0;
  ldrBuf[ldrIdx] = analogRead(PHOTO_PIN);
  ldrIdx = (ldrIdx + 1) % 8;
  long ldrAvg = 0;
  for (byte i = 0; i < 8; i++) ldrAvg += ldrBuf[i];
  ldrAvg /= 8;

  // Гістерезис — перемикаємо рівень тільки якщо перейшли поріг на 150 одиниць
  static byte brightLevel = 1; // 0=мін, 1=середній, 2=макс
  if (brightLevel != 0 && ldrAvg < BRIGHT_LOW  - 150) brightLevel = 0;
  if (brightLevel != 2 && ldrAvg > BRIGHT_HIGH + 150) brightLevel = 2;
  if (brightLevel == 0 && ldrAvg > BRIGHT_LOW  + 150) brightLevel = 1;
  if (brightLevel == 2 && ldrAvg < BRIGHT_HIGH - 150) brightLevel = 1;

  byte lcdTarget, ledTarget;
  switch (brightLevel) {
    case 0: lcdTarget = LCD_BRIGHT_MIN; ledTarget = LED_BRIGHT_MIN; break;
    case 1: lcdTarget = LCD_BRIGHT_MID; ledTarget = LED_BRIGHT_MID; break;
    default:lcdTarget = LCD_BRIGHT_MAX; ledTarget = LED_BRIGHT_MAX; break;
  }

  // Плавний перехід кроком 2 — повільніше але без мигання
  if (currentLcdBright < lcdTarget) currentLcdBright = min((int)lcdTarget, currentLcdBright + 2);
  else if (currentLcdBright > lcdTarget) currentLcdBright = max((int)lcdTarget, currentLcdBright - 2);
  setLcdBright(currentLcdBright);

  if (currentLedBright < ledTarget) currentLedBright = min((int)ledTarget, currentLedBright + 2);
  else if (currentLedBright > ledTarget) currentLedBright = max((int)ledTarget, currentLedBright - 2);
  updateFishLED();
}

// Веселка для рівня 4 — глобальний лічильник фази
uint32_t rainbowTimer_ms = 0;
byte rainbowHue = 0;

// HSV→RGB спрощений (h: 0-255, s=255, v=bright)
void hsvToRgb(byte h, byte bright, byte &r, byte &g, byte &b) {
  byte region = h / 43;
  byte rem    = (h - region * 43) * 6;
  byte q = (bright * (255 - rem)) >> 8;
  byte t = (bright * rem) >> 8;
  switch (region) {
    case 0: r=bright; g=t;      b=0;      break;
    case 1: r=q;      g=bright; b=0;      break;
    case 2: r=0;      g=bright; b=t;      break;
    case 3: r=0;      g=q;      b=bright; break;
    case 4: r=t;      g=0;      b=bright; break;
    default:r=bright; g=0;      b=q;      break;
  }
}

/*
  Модель кльову — бальна система 0..100, потім → оцінка 0..3
  Фактори:
    1. Швидкість зміни тиску (delta, Па/год)       — основний
    2. Відхилення від базового тиску місцевості     — важливий
    3. Адаптація риби після стрибка тиску           — важливий
    4. Час доби + сезон                             — додатковий (якщо useTime)
  Тип риби впливає на вагу факторів і пороги.
*/

/*
  getSeason() — визначає пору року з урахуванням:
  1. Календарного місяця і числа (основа)
  2. Прогнозу температури (підтверджує перехід якщо близько до межі сезону)
  Повертає: 1=зима, 2=весна, 3=літо, 4=осінь
*/
byte getSeason() {
  DateTime now2 = rtc.now();
  byte mo  = now2.month();
  byte day = now2.day();

  // Базовий сезон по місяцю
  byte season;
  if      (mo == 12 || mo <= 2)  season = 1; // зима
  else if (mo >= 3  && mo <= 5)  season = 2; // весна
  else if (mo >= 6  && mo <= 8)  season = 3; // літо
  else                           season = 4; // осінь

  // Температурне коригування — тільки біля меж сезонів і дуже м'яко:
  // прогноз не такий точний як дата, тому він може підтвердити перехід,
  // але не має різко перекидати сезон посеред місяця.
  if (!forecastValid) return season;

  int warmCount = 0;
  int coldCount = 0;
  int startIdx = forecastCurrentIdx();
  if (startIdx >= 0) {
    for (int i = startIdx; i < startIdx + 48 && i < FORECAST_HOURS; i++) {
      if (forecast[i].temp > 20) warmCount++;
      if (forecast[i].temp < 5)  coldCount++;
    }
  }

  // Весна→літо: тільки останній тиждень травня і якщо 2 доби переважно теплі.
  if (season == 2 && mo == 5 && day >= 25 && warmCount >= 34) return 3;

  // Літо→осінь: тільки останні дні серпня, коли тепла явно мало.
  if (season == 3 && mo == 8 && day >= 27 && warmCount < 16) return 4;

  // Осінь→зима: останній тиждень листопада + стійкий холод.
  if (season == 4 && mo == 11 && day >= 25) {
    if (coldCount >= 32) return 1;
  }

  // Зима→весна: кінець лютого може стати весною тільки при явному теплі,
  // а початок березня може лишитись зимою тільки при стійкому холоді.
  if (season == 1 && mo == 2 && day >= 25 && coldCount < 12 && warmCount >= 8) return 2;
  if (season == 2 && mo == 3 && day <= 7 && coldCount >= 32) {
    return 1;
  }

  return season;
}

byte getSeasonTransition(byte &fromSeason, byte &toSeason) {
  DateTime now2 = rtc.now();
  byte mo  = now2.month();
  byte day = now2.day();
  fromSeason = getSeason();
  toSeason = fromSeason;

  // 14-денні календарні переходи. Прогноз температури не керує фазою,
  // бо він неточний; він тільки м'яко впливає на сам score окремо.
  if (mo == 2 && day >= 22) { fromSeason = 1; toSeason = 2; return (byte)map(day, 22, 28, 10, 90); }
  if (mo == 3 && day <= 7)  { fromSeason = 1; toSeason = 2; return (byte)map(day, 1, 7, 55, 100); }
  if (mo == 5 && day >= 24) { fromSeason = 2; toSeason = 3; return (byte)map(day, 24, 31, 10, 90); }
  if (mo == 6 && day <= 7)  { fromSeason = 2; toSeason = 3; return (byte)map(day, 1, 7, 55, 100); }
  if (mo == 8 && day >= 24) { fromSeason = 3; toSeason = 4; return (byte)map(day, 24, 31, 10, 90); }
  if (mo == 9 && day <= 7)  { fromSeason = 3; toSeason = 4; return (byte)map(day, 1, 7, 55, 100); }
  if (mo == 11 && day >= 24){ fromSeason = 4; toSeason = 1; return (byte)map(day, 24, 30, 10, 90); }
  if (mo == 12 && day <= 7) { fromSeason = 4; toSeason = 1; return (byte)map(day, 1, 7, 55, 100); }
  return 0;
}

int timeBonusForSeason(byte season, byte h) {
  switch (season) {
    case 1: // зима — полудень
      if (h >= 11 && h <= 15) return 10;
      if (h >= 9  && h <= 17) return 0;
      return -8;
    case 2: // весна — день
      if (h >= 10 && h <= 18) return 10;
      if (h >= 8  && h <= 20) return 3;
      return -7;
    case 3: // літо — ранок і вечір, обід погано
      if ((h >= 5 && h <= 9) || (h >= 18 && h <= 22)) return 15;
      if (h >= 10 && h <= 17) return -10; // спека — трохи гірше але не катастрофа
      // Літня ніч не однакова для всіх: хижак і короп часто годуються в темряві.
      if (fishType == 1 || fishType == 3 || fishType == 4) return 5;
      if (fishType == 2) return 0;
      return 0;
    case 4: // осінь — день
      if (h >= 9 && h <= 17) return 10;
      if (h >= 7 && h <= 19) return 3;
      return -8;
  }
  return 0;
}

// Повертає бонус/штраф часу доби (-10..+15)
int timeBonus() {
  if (!useTime) return 0;
  byte h = (byte)hrs;
  byte fromSeason = 0, toSeason = 0;
  byte pct = getSeasonTransition(fromSeason, toSeason);
  if (pct == 0 || fromSeason == toSeason) return timeBonusForSeason(getSeason(), h);

  int a = timeBonusForSeason(fromSeason, h);
  int b = timeBonusForSeason(toSeason, h);
  return (a * (100 - pct) + b * pct) / 100;
}

// ---- Стан адаптаційного циклу ----
// Зберігаємо скільки мм змінився тиск від adaptPress (для таблиці)
// (змінні jumpMagnitudeMm, jumpStartMs, jumpExtraHits визначені вище)

// Повертає необхідний час адаптації в мс за таблицею
// magnitude — повна зміна тиску в мм
// gradientH  — за скільки годин відбулась зміна (для множника)
// phase      — 0=Bad, 1=50/50, 2=Good — повертає час закінчення цієї фази
uint32_t adaptPhaseMs(float magnitude, float gradientH, byte phase) {
  // Таблиця базових годин для трьох фаз (Bad, 50/50, GoodStart)
  float bad_h, mid_h, good_h;
  if      (magnitude >= 8.0f) { bad_h=3.0f;  mid_h=5.5f;  good_h=10.0f; }
  else if (magnitude >= 4.0f) { bad_h=1.5f;  mid_h=3.0f;  good_h=6.0f;  }
  else                        { bad_h=0.5f;  mid_h=1.0f;  good_h=2.0f;  }

  // Аерація при дощі — скорочуємо Bad на 25% якщо є опади
  bool raining = forecastValid && (forecastCurrentIdx() >= 0) && (forecast[forecastCurrentIdx()].wid >= 51);
  if (raining && phase == 0) bad_h *= 0.75f;

  // Множник швидкості зміни
  float mult = 1.0f;
  if      (gradientH > 0 && gradientH <= 12.0f) mult = 1.2f; // різко — повільніша адаптація
  else if (gradientH >= 48.0f)                  mult = 0.7f;  // плавно — швидша адаптація

  float target_h = (phase == 0) ? bad_h : (phase == 1) ? mid_h : good_h;
  target_h *= mult;

  // Штраф за додаткові удари — додаємо тільки до bad_h (фаза 0).
  // Для mid і good — кумулятивний ефект вже врахований через подовження bad фази:
  // риба виходить в 50% і Good пізніше бо bad тривала довше.
  if (phase == 0) target_h += (float)jumpExtraHits;

  return (uint32_t)(target_h * 3600 * 1000);
}

bool lowPressTackleColumn() {
  float belowBase = basePressureSet() ? (SEA_PRESS_MM - dispPres) : 0.0f;
  float belowAdapt = adaptPress - dispPres;
  bool recentLowAdapt = lastAdaptDoneMs > 0 &&
                        (millis() - lastAdaptDoneMs) < 2UL * 3600UL * 1000UL &&
                        basePressureSet() &&
                        lastAdaptPress < SEA_PRESS_MM - 2.0f;

  return belowBase > 3.0f ||
         (pressJumped && (belowBase > 1.0f || belowAdapt > 1.0f)) ||
         recentLowAdapt;
}

// Оновлення стану адаптації — викликати після кожного розрахунку delta
void updateAdaptation() {
  if (!deltaReady) return;
  int absDelta = abs(delta);

  // Лічильник осциляцій — скільки разів змінився напрямок тиску
  static byte oscCount    = 0;
  static int  lastDeltaSign = 0; // +1, -1, або 0

  // Поріг руху тиску — >30 Па/год (~0.22 мм/год)
  const int OSC_THR = 30;

  if (absDelta > OSC_THR) {
    int sign = (delta > 0) ? 1 : -1;
    if (lastDeltaSign != 0 && sign != lastDeltaSign) oscCount++;
    lastDeltaSign = sign;

    if (!pressJumped) {
      const uint32_t ADAPT_CREDIT_MAX_MS = 2UL * 3600UL * 1000UL;
      uint32_t nowMs = millis();
      bool hasRecentAdapt = lastAdaptDoneMs > 0 &&
                            (nowMs - lastAdaptDoneMs) < 6UL * 3600UL * 1000UL &&
                            fabsf(adaptPress - lastAdaptPress) <= 2.0f;
      uint32_t creditMs = hasRecentAdapt ? min(lastAdaptCreditMs, ADAPT_CREDIT_MAX_MS) : 0;

      pressJumped      = true;
      stableStartMs    = 0;
      jumpStartMs      = nowMs - creditMs;
      jumpExtraHits    = 0;
      jumpMagnitudeMm  = fabsf(dispPres - adaptPress);
    } else if (stableStartMs > 0) {
      // Знову рухнувся під час адаптації — "удар по голові"
      jumpExtraHits = min((int)jumpExtraHits + 1, 10);
      stableStartMs = 0; // скидаємо відлік
      // Оновлюємо величину якщо стало більше
      float newMag = fabsf(dispPres - adaptPress);
      if (newMag > jumpMagnitudeMm) jumpMagnitudeMm = newMag;
    }
  } else {
    // Тиск стабілізувався (±30 Па ≈ ±0.22 мм — це рівень шуму BME280)
    lastDeltaSign = 0;

    if (pressJumped) {
      if (stableStartMs == 0) {
        stableStartMs = millis();
        adaptPress    = dispPres;
        // Розраховуємо величину стрибка від початкового adaptPress
        if (jumpMagnitudeMm < 0.5f) jumpMagnitudeMm = 0.5f; // мінімум
      }

      // Скільки годин тривав стрибок (для градієнту)
      float gradH = (jumpStartMs > 0) ? (float)(stableStartMs - jumpStartMs) / 3600000.0f : 24.0f;
      gradH = constrain(gradH, 0.1f, 96.0f);

      // Визначаємо поточну фазу адаптації
      uint32_t elapsed = millis() - stableStartMs;
      uint32_t bad_end  = adaptPhaseMs(jumpMagnitudeMm, gradH, 0);
      uint32_t mid_end  = adaptPhaseMs(jumpMagnitudeMm, gradH, 1);
      uint32_t good_end = adaptPhaseMs(jumpMagnitudeMm, gradH, 2);

      // Зберігаємо поточну фазу глобально для відображення
      // (0=Bad, 1=50/50, 2=AdaptGood, 3=Done)
      if (elapsed >= good_end) {
        const uint32_t ADAPT_CREDIT_MAX_MS = 2UL * 3600UL * 1000UL;
        pressJumped   = false;
        lastAdaptDoneMs = millis();
        lastAdaptPress  = dispPres;
        lastAdaptCreditMs = min(good_end, ADAPT_CREDIT_MAX_MS);
        stableStartMs = 0;
        oscCount      = 0;
        jumpExtraHits = 0;
        jumpMagnitudeMm = 0;
        adaptPress    = dispPres;
      }
      (void)bad_end; (void)mid_end; // використовуються в calcFishScore
    } else {
      if (absDelta <= OSC_THR &&
          lastAdaptDoneMs > 0 &&
          fabsf(dispPres - lastAdaptPress) <= 2.0f) {
        lastAdaptDoneMs = millis();
      }
      oscCount = 0;
    }
  }
}

// ------------------------- МІСЯЦЬ -------------------------
// Фаза місяця 0..29 (0=новий, ~15=повний). Без бібліотек.
byte getMoonPhase() {
  DateTime n = rtc.now();
  int y = n.year(), mo = n.month(), d = n.day();
  // Спрощений юліанський день
  long jd = 367L*y - (7*(y+(mo+9)/12))/4 + (275*mo)/9 + d + 1721013L;
  long phase = (jd - 2451549L + 1) % 30;
  if (phase < 0) phase += 30;
  return (byte)phase;
}

const char* moonPhaseName(byte p) {
  if      (p == 0)       return "Новий місяць";
  else if (p <= 6)       return "Молодик";
  else if (p <= 8)       return "Перша чверть";
  else if (p <= 13)      return "Прибуває";
  else if (p <= 16)      return "Повний місяць";
  else if (p <= 21)      return "Спадає";
  else if (p <= 23)      return "Остання чверть";
  else                   return "Старий місяць";
}

const char* moonPhaseIcon(byte p) {
  if      (p == 0)       return "\U0001F311"; // 🌑
  else if (p <= 6)       return "\U0001F312"; // 🌒
  else if (p <= 8)       return "\U0001F313"; // 🌓
  else if (p <= 13)      return "\U0001F314"; // 🌔
  else if (p <= 16)      return "\U0001F315"; // 🌕
  else if (p <= 21)      return "\U0001F316"; // 🌖
  else if (p <= 23)      return "\U0001F317"; // 🌗
  else                   return "\U0001F318"; // 🌘
}

// ===================== МІСЯЦЬ — ФАЗА =====================
// Повертає бонус кльову від фази Місяця.
// Повня і новий місяць: невеликий плюс (риба трохи активніша).
// Перша/остання чверть: мінімальний бонус.
// Вплив навмисно малий — тиск і погода важливіші в рази.
int moonBonus() {
  if (!useMoon) return 0;
  byte p = getMoonPhase(); // 0..29
  // Новий місяць (p=0-2, 27-29): +4  — менше нічного світла = риба сміливіша
  // Повня (p=12-17):             +4  — активізує планктон → ланцюжок хижак/мирна
  // Перша/остання чверть:        +2  — слабкий позитив
  if      (p <= 2 || p >= 27)   return 4;
  else if (p >= 12 && p <= 17)  return 4;
  else if (p >= 6  && p <= 9)   return 2;
  else if (p >= 20 && p <= 23)  return 2;
  return 0;
}
// ================================================================

byte calcFishScore() {
  // Повертаємо 255 ("⏳ Визначаємо...") поки не накопичено мінімум 3 зразки тиску (~30 хв).
  // Без цього після перезапуску delta=0 і score одразу показує "відмінно" — це хибно.
  if (!deltaReady || pressureSampleCount < 3) return 255;
  // Також не рахуємо без базового тиску — нема з чим порівнювати.
  if (!basePressureSet()) return 255;

  static uint32_t cacheMs      = 0;
  static int     cacheDelta    = 0x7FFF;
  static float   cachePres     = -1.0f;
  static byte    cacheFishType = 255;
  static bool    cacheJumped   = false;
  static int     cacheFcIdx    = -99;
  static byte    cachedScore   = 255;
  static bool    cacheUseMoon  = false;
  static bool    cacheUseTime  = false;
  static bool    cacheUseSpawn = false;
  static byte    cacheWater    = 0xFF;
  uint32_t now_ms = millis();
  int      fcIdx  = forecastCurrentIdx();
  bool inputsChanged = (delta != cacheDelta || fabsf(dispPres - cachePres) > 0.05f
                        || fishType != cacheFishType || pressJumped != cacheJumped
                        || fcIdx != cacheFcIdx
                        || useMoon  != cacheUseMoon
                        || useTime  != cacheUseTime
                        || useSpawn != cacheUseSpawn
                        || waterType != cacheWater);
  if (cachedScore != 255 && !inputsChanged && now_ms - cacheMs < 2000) return cachedScore;
  cacheDelta    = delta;
  cachePres     = dispPres;
  cacheFishType = fishType;
  cacheJumped   = pressJumped;
  cacheFcIdx    = fcIdx;
  cacheUseMoon  = useMoon;
  cacheUseTime  = useTime;
  cacheUseSpawn = useSpawn;
  cacheWater    = waterType;
  cacheMs       = now_ms;

  int score = 60; // стартовий бал

  // --- ФАКТОР 1: швидкість зміни тиску + напрямок ---
  int absDelta = abs(delta);
  int thr_bad, thr_mid, thr_ok;
  // 0=мирна вся, 1=хижа, 2=карась, 3=короп, 4=змішана К+Кр, 5=змішана вся
  switch (fishType) {
    case 1: thr_bad=350; thr_mid=200; thr_ok=90; break; // хижа — найстійкіша
    case 2: thr_bad=220; thr_mid=110; thr_ok=50; break; // карась — чутливий, але не від шуму 0.2 мм
    case 3: thr_bad=260; thr_mid=130; thr_ok=60; break; // короп — помірно чутливий
    case 4: thr_bad=240; thr_mid=120; thr_ok=55; break; // карась+короп — середнє
    case 5: thr_bad=240; thr_mid=120; thr_ok=55; break; // вся мирна
    default:thr_bad=240; thr_mid=120; thr_ok=55; break; // мирна вся
  }
  // Штраф за зміну тиску залежить від швидкості:
  // різка зміна (>thr_bad) = великий штраф; плавна (thr_ok..thr_mid) = помірний.
  // Додатково: падіння тиску штрафується сильніше ніж ріст (риба важче переносить падіння).
  if (absDelta >= thr_bad) {
    // Різко — штраф залежить від наскільки різко, +5 якщо падіння
    int sharpPenalty = (absDelta >= thr_bad * 2) ? 42 : 36;
    if (delta < 0) sharpPenalty += 5; // падіння гірше за ріст
    score -= sharpPenalty;
  } else if (absDelta >= thr_mid) {
    // Помірно різко — менший штраф ніж раніше, але все одно суттєвий
    // Лінійно від 20 (на нижній межі thr_mid) до 38 (на верхній межі thr_bad)
    float ratio = (float)(absDelta - thr_mid) / (float)(thr_bad - thr_mid);
    int pen = (int)(14.0f + ratio * 16.0f); // 14..30
    if (delta < 0) pen += 4; // падіння гірше
    score -= pen;
  } else if (absDelta >= thr_ok) {
    // Плавна зміна — мінімальний штраф (риба встигає адаптуватись поступово)
    float ratio = (float)(absDelta - thr_ok) / (float)(thr_mid - thr_ok);
    int pen = (int)(1.0f + ratio * 5.0f); // 1..6
    if (delta < 0) pen += 2; // падіння гірше
    score -= pen;
  } else {
    score += 12; // стабільно — добрий бонус
  }

  // Хижак любить помірну нестабільність — бонус замість штрафу
  // Але НЕ додаємо ще й напрямковий бонус щоб уникнути задвоєння
  if (fishType == 1 && absDelta >= thr_ok && absDelta < thr_mid) {
    score += 12; // нейтралізуємо штраф і даємо плюс (без додаткового напрямку)
  } else if (absDelta < thr_bad) {
    // Напрямок тренду для всіх інших типів риби
    if      (delta >  thr_ok) score += 5;   // повільно росте — добре
    else if (delta < -thr_ok) score -= 7;   // повільно падає — погано
  }

  // --- ФАКТОР 2: відхилення від базового тиску ---
  // Риба адаптується до поточного тиску за 1-2 доби незалежно від абсолютного значення.
  // Тому відхилення від бази НЕ штрафуємо — адаптація вже врахована в Ф3 (pressJumped).
  // Єдиний виняток: якщо відхилення > 15мм і тиск стабільний — ймовірно юзер неправильно
  // ввів базу. Даємо мінімальний штраф як сигнал, але не як реальний вплив на рибу.
  float diff = dispPres - SEA_PRESS_MM;
  float absDiff = fabsf(diff);
  if (!pressJumped && absDiff > 15.0f) score -= 2; // лише підказка про можливу помилку бази

  // --- ФАКТОР 3: адаптація (таблиця Bad/50%/GD за величиною і швидкістю стрибка) ---
  if (pressJumped) {
    float gradH;
    uint32_t adaptedMs;

    if (stableStartMs > 0) {
      // Тиск вже стабілізувався — рахуємо від моменту стабілізації
      adaptedMs = millis() - stableStartMs;
      gradH = (jumpStartMs > 0 && stableStartMs > jumpStartMs)
              ? (float)(stableStartMs - jumpStartMs) / 3600000.0f : 24.0f;
    } else {
      // Тиск ще рухається — рахуємо скільки вже йде стрибок від jumpStartMs.
      // Поки не стабілізувався — завжди в Bad-фазі, але не "заморожуємо" рахунок на 0:
      // показуємо скільки вже пройшло щоб не сидіти в Bad безкінечно при повільному русі.
      adaptedMs = (jumpStartMs > 0) ? (millis() - jumpStartMs) : 0;
      // Градієнт ще невідомий — використовуємо поточний час стрибка як оцінку
      gradH = (jumpStartMs > 0) ? (float)(millis() - jumpStartMs) / 3600000.0f : 24.0f;
    }
    gradH = constrain(gradH, 0.1f, 96.0f);
    float mag = (jumpMagnitudeMm > 0.5f) ? jumpMagnitudeMm : fabsf(dispPres - adaptPress);
    if (mag < 0.5f) mag = 0.5f;

    uint32_t bad_end = adaptPhaseMs(mag, gradH, 0);
    uint32_t mid_end = adaptPhaseMs(mag, gradH, 1);

    if (stableStartMs == 0) {
      // Тиск ще рухається — завжди Bad, але штраф зменшується якщо рухається довго (>4 год)
      // щоб не карати нескінченно при дуже повільному плавному русі
      float jumpHours = (jumpStartMs > 0) ? (float)(millis() - jumpStartMs) / 3600000.0f : 0.0f;
      int pen = (jumpHours > 4.0f) ? 12 : 22; // довго рухається повільно → менший штраф
      score -= pen;
    } else if (adaptedMs < bad_end) {
      // Фаза Bad — помірний штраф, без подвійного покарання від Ф2
      score -= 22;
    } else if (adaptedMs < mid_end) {
      // Фаза 50/50 — штраф зменшується від 12 до 6
      float ratio = (float)(adaptedMs - bad_end) / (float)(mid_end - bad_end);
      score -= (int)(12 * (1.0f - ratio * 0.5f)); // 12→6
    } else {
      // Фаза GoodStart — дуже маленький залишковий штраф
      score -= 2;
    }
  }

  // --- ФАКТОР 5: зовнішня температура з прогнозу (м'який вплив) ---
  int idx = forecastCurrentIdx();
  if (forecastValid && idx >= 0) {
    float tempOut = forecast[idx].temp;
    int tempTrend = tempTrendC();

    // Температурний градієнт за 4 год (різке потепління + падаючий тиск — погано)
    int idx4 = idx - 4;
    if (idx4 >= 0) {
      float tempPrev = forecast[idx4].temp;
      float gradC = tempOut - tempPrev;
      if (gradC > 7.0f && delta < 0) {
        score -= 8; // прогнозна температура неточна — м'який вплив
      } else if (gradC >= 2.0f && gradC <= 4.0f) {
        byte mo2 = rtc.now().month();
        if (mo2 >= 3 && mo2 <= 5) score += 3;
      }
      prevOutdoorTemp = tempOut;
      prevTempTime    = millis();
    }

    // Абсолютна температура — м'який вплив (пом'якшено вдвічі бо дані не ідеальні)
    byte mo = rtc.now().month();
    if (mo==12 || mo<=2) {
      if      (tempOut < 2.0f)  score -= 3;
      else if (tempOut < 4.0f)  score -= 1;
      else if (tempOut <= 8.0f) score += 1;
    }
    else if (mo >= 3 && mo <= 5) {
      if      (tempOut < 6.0f)  score -= 2;
      else if (tempOut <= 10.0f) score += 1;
      else if (tempOut <= 18.0f) score += 2;
      else if (tempOut > 24.0f)  score -= 1;
    }
    else if (mo >= 6 && mo <= 8) {
      if      (tempOut < 14.0f) score -= 2;
      else if (tempOut <= 26.0f) score += 2;
      else if (tempOut > 30.0f)  score -= 3;
      else                       score -= 1;
    }
    else {
      if      (tempOut > 18.0f) score += 2;
      else if (tempOut > 10.0f) score += 1;
      else if (tempOut < 5.0f)  score -= 2;
    }

    if (tempTrend >= 4) {
      score += (rtc.now().month() >= 3 && rtc.now().month() <= 5) ? 8 : 4;
    } else if (tempTrend >= 2) {
      score += (rtc.now().month() >= 3 && rtc.now().month() <= 5) ? 4 : 2;
    } else if (tempTrend <= -4) {
      score -= 8;
    } else if (tempTrend <= -2) {
      score -= 4;
    }
  }

  // --- ФАКТОР 6: погодні явища (WMO) + вологість ---
  if (forecastValid && idx >= 0) {
    uint8_t wid = forecast[idx].wid;
    uint8_t pop = forecast[idx].pop;
    float   tC  = forecast[idx].temp;
    uint8_t hum = forecast[idx].hum;
    uint8_t cloud = forecast[idx].cloud;

    // Гроза або сильна злива
    if (wid >= 95 || (wid >= 80 && wid <= 82 && pop > 70)) {
      score -= 40;
    }
    // Передгрозовий жор: тиск плавно падає + висока хмарність + тепло
    // Бонус менший (+12) бо падіння тиску вже дало штраф — не перекриваємо повністю
    else if (delta < -30 && delta > -120 && pop > 60 && tC > 18.0f) {
      if (wid < 80) score += 12;
    }
    // Невеликий дощ при стабільному тиску
    else if (wid == 51 || wid == 61) {
      if (abs(delta) < 30) score += 10;
    }

    // Вологість — один блок без задвоєння
    if      (hum > 85 && absDelta < thr_bad) score += 4;   // перед дощем — карась активний
    else if (hum >= 60 && hum <= 80 && absDelta < thr_ok) score += 2; // оптимум
    else if (hum < 30 && tC > 25.0f) score -= 4;           // суха спека — риба пасивна

    bool dayLight = (hrs >= 9 && hrs <= 18);
    if (dayLight && cloud >= 60 && absDelta < thr_bad) {
      score += (fishType == 1) ? 2 : 5;
    } else if (dayLight && cloud <= 20 && tC > 22.0f && (fishType == 2 || fishType == 3 || fishType == 4 || fishType == 0 || fishType == 5)) {
      score -= 3;
    }
  }
  // --- ФАКТОР ВІТЕР: сильний вітер = мінус для поплавочника ---
  if (forecastValid && idx >= 0) {
    uint8_t ws = forecast[idx].wind; // м/с
    // Карась і мирна риба дуже бояться хвилі
    // Вітер до 3 м/с — норма, 3-6 — трохи гірше, 6-9 — поганий поплавок, >9 — донка єдиний варіант
    if (ws >= 12) {
      score -= 30; // буревій — риба ховається, не клює
    } else if (ws >= 9) {
      score -= 18; // сильний вітер — важко ловити будь-чим
    } else if (ws >= 6) {
      // Для карася (2) і мирної (0,5) — додатковий штраф (поплавок здуває)
      score -= (fishType == 2 || fishType == 0 || fishType == 5) ? 12 : 7;
    } else if (ws >= 3) {
      score -= 4; // легкий вітер — незначно гірше
    }
    // Слабкий вітерець при теплій погоді весною/літом — навіть трохи краще (перемішує воду)
    // 1-3 м/с навесні/влітку — нейтрально (перемішує воду але не заважає)
    // вже дав -4 вище, повертаємо +3 = чистий штраф -1 (майже нуль)
    if (ws >= 1 && ws <= 3) {
      byte mo_w = rtc.now().month();
      if (mo_w >= 4 && mo_w <= 9) score += 4; // повністю нейтралізуємо -4
    }
  }

  // --- ФАКТОР НЕРЕСТ ---
  score += spawnScoreAdjust();

  // --- ФАКТОР 8: REAL-TIME погода (поточний стан, вища пріоритетність ніж прогноз) ---
  // Якщо дані свіжі (< 40 хв) — замінюємо деякі прогнозні оцінки реальними.
  // Це основний фактор точності: дощ, тиск і вітер зараз важливіше за прогноз.
  if (rtWeather.valid && (millis() - rtWeather.fetchedAt) < 40UL * 60 * 1000) {
    uint8_t rtCode = rtWeather.weatherCode;
    float   rtPrec = rtWeather.precipitation;
    float   rtWind = rtWeather.windSpeed;
    float   rtTemp = rtWeather.temperature;

    // --- Дощ зараз: основний блок ---
    if (rtPrec > 0.0f || (rtCode >= 51 && rtCode <= 82)) {
      // Визначаємо інтенсивність дощу
      bool lightRain  = (rtPrec > 0.0f && rtPrec <= 1.5f) || rtCode == 51 || rtCode == 61;
      bool modRain    = (rtPrec > 1.5f && rtPrec <= 5.0f) || rtCode == 53 || rtCode == 63;
      bool heavyRain  = (rtPrec > 5.0f)                   || rtCode == 55 || rtCode == 65;
      bool showers    = (rtCode >= 80 && rtCode <= 82);

      // Умови при яких дощ = плюс (легкий, тиск стабільний, тепло):
      bool goodRainCond = (absDelta < thr_ok) && (rtTemp > 12.0f) && !showers;

      if (lightRain && goodRainCond) {
        // Легкий дощ при стабільному тиску і теплі — відмінно для мирної риби
        score += (fishType == 1) ? 4 : 14; // хижак — менше, мирна — більше
        Serial.println("[score] +легкий дощ/стабільний тиск");
      } else if (modRain && goodRainCond) {
        // Помірний дощ — добре але менше ніж легкий
        score += (fishType == 1) ? 2 : 8;
      } else if (heavyRain || showers) {
        // Сильний дощ або злива — завжди погано
        score -= 20;
        Serial.println("[score] -сильний дощ/злива");
      } else if (lightRain && !goodRainCond) {
        // Легкий дощ але тиск нестабільний або холодно — нейтрально/мінус
        score -= 4;
      }
    }

    // --- Реальний тиск зараз (rtWeather.surfacePressure) ---
    // Порівнюємо з базовим: якщо реальний тиск суттєво відрізняється від прогнозу →
    // значить прогноз помилявся. Коригуємо оцінку відхилення від норми.
    if (rtWeather.surfacePressure > 680.0f && rtWeather.surfacePressure < 820.0f && basePressureSet()) {
      float rtDiff = rtWeather.surfacePressure - SEA_PRESS_MM;
      float rtAbsDiff = fabsf(rtDiff);
      // М'яка корекція (вага 30%) поверх вже розрахованого Ф2
      int rtPresAdj = 0;
      if      (rtAbsDiff <= 0.5f) rtPresAdj =  3; // точний збіг — бонус
      else if (rtAbsDiff > 20.0f) rtPresAdj = -3; // великий відхил — додатковий мінус
      score += rtPresAdj;
    }

    // --- Реальний вітер зараз ---
    // Якщо вітер зараз сильніший ніж прогноз передбачав — додатковий штраф
    if (forecastValid && idx >= 0) {
      float fcWind = (float)forecast[idx].wind;
      if (rtWind > fcWind + 3.0f) {
        // Вітер сильніший ніж очікувалось
        int extraPen = (int)((rtWind - fcWind) * 1.5f);
        extraPen = constrain(extraPen, 0, 10);
        score -= extraPen;
      } else if (rtWind < fcWind - 2.0f && fcWind >= 6.0f) {
        // Вітер слабший ніж прогноз казав — добра новина
        score += 3;
      }
    }
  }

  // --- ФАКТОР ТИП ВОДОЙМИ ---
  // Річка (waterType==1): більша насиченість киснем → карась/мирна активніша при спеці;
  // але сильна течія погіршує кльов в повінь (весна).
  if (waterType == 1) {
    byte mo_w = rtc.now().month();
    if (mo_w >= 4 && mo_w <= 5 && forecastValid && idx >= 0 && forecast[idx].temp > 10) {
      // Весняна повінь — складно ловити на річці
      score -= 8;
    } else if (forecastValid && idx >= 0 && forecast[idx].temp > 26 && (fishType == 2 || fishType == 0 || fishType == 5)) {
      // Спека: річка краще провітрюється → карась активніший
      score += 5;
    }
  }

  // Час доби — обмежений вплив ±8 щоб не перекривати фізичні фактори
  int tb = constrain(timeBonus(), -8, 8);
  score += tb;

  // --- ФАКТОР 7: м'яке злиття тиску прогнозу ---
  // Прогнозний тиск легко коригує оцінку відхилення від норми (вага 15%)
  // Екранний тиск НЕ змінюється — тільки розрахунок кльову
  if (forecastValid && idx >= 0) {
    float fcPress = (float)forecast[idx].pressure; // мм рт.ст. з прогнозу
    // Змішуємо: 85% датчик + 15% прогноз
    float blendedPres = dispPres * 0.95f + fcPress * 0.05f;
    // Бонус/штраф тільки якщо прогноз суттєво відрізняється від датчика (>2 мм)
    float fcBias = blendedPres - dispPres;
    if (fabsf(fcBias) > 2.0f) {
      // Прогноз каже що тиск вищий ніж датчик → трохи краще
      // Прогноз каже нижчий → трохи гірше
      int fcAdj = (int)(fcBias * 0.3f);
      fcAdj = constrain(fcAdj, -2, 2);
      score += fcAdj;
    }

    // --- Корекція шансу дощу ---
    // dispRain вже скоригований прогнозом в plotSensorsTick — нічого додаткового не потрібно
  }

  // --- ФАКТОР МІСЯЦЬ: фаза + вікно сходу/заходу ---
  score += moonBonus();

  // --- БОНУС: напрямок вітру (малий вплив ±4) ---
  // Захід/південь = тепліше повітря, риба активніша
  // Північ/схід = холодний фронт, риба пригнічується
  if (forecastValid && idx >= 0) {
    uint16_t wdir = forecast[idx].windDir;
    uint8_t  wspd = forecast[idx].wind;
    if (wspd >= 3) { // тільки якщо вітер реально є (>=3 м/с)
      // Захід (225-315°) або Південь (135-225°) — теплі вітри
      if ((wdir >= 135 && wdir <= 315)) {
        score += (wspd >= 6) ? 2 : 4; // сильний захід вже не так добре
      }
      // Північ (315-360° або 0-45°) або Схід (45-135°) — холодні вітри
      else {
        score -= (wspd >= 8) ? 4 : 2;
      }
    }
  }

  // --- БОНУС: ранковий/вечірній клюв влітку для карася (малий вплив ±4) ---
  // Вже є в timeBonusForSeason (літо: зоря +15, обід -10), але тут уточнюємо
  // для карася зокрема: він ОСОБЛИВО чутливий до сонця — додатковий бонус на зорі
  if (useTime && (fishType == 2 || fishType == 0 || fishType == 4 || fishType == 5)) {
    byte mo_t = rtc.now().month();
    byte h_t  = (byte)hrs;
    // Літо (червень-серпень): карась клює на зорі (5-8) і на заході (19-21), обід — штраф
    if (mo_t >= 6 && mo_t <= 8) {
      if (h_t >= 5 && h_t <= 8)   score += 4; // зоря — пік
      else if (h_t >= 19 && h_t <= 21) score += 3; // вечір — добре
      else if (h_t >= 11 && h_t <= 16) score -= 4; // полудень — спека, карась ховається
    }
    // Травень/вересень — тепло але не спека, ранок теж кращий
    else if (mo_t == 5 || mo_t == 9) {
      if (h_t >= 6 && h_t <= 9)   score += 3;
      else if (h_t >= 18 && h_t <= 20) score += 2;
    }
  }

  score = constrain(score, 0, 100);
  // Якщо тиск стабільний, немає грози і вітер терпимий — мінімум 50 (стабільний тиск важливий)
  // Але не гарантуємо якщо є гроза, буревій або пік нересту
  bool pressGood = basePressureSet() && (absDelta < thr_ok) && (absDiff <= 15.0f) && !pressJumped;
  bool badCondition = false;
  if (forecastValid && idx >= 0) {
    uint8_t wid2 = forecast[idx].wid;
    uint8_t ws2  = forecast[idx].wind;
    if (wid2 >= 95) badCondition = true;        // гроза
    if (ws2 >= 12)  badCondition = true;        // буревій
  }
  if (useSpawn && spawnPhase() == 2) badCondition = true; // пік нересту
  if (pressGood && !badCondition && score < 50) score = 50;

  if      (score >= 75) { cachedScore = 3; return 3; }
  else if (score >= 50) { cachedScore = 2; return 2; }
  else if (score >= 25) { cachedScore = 1; return 1; }
  else                  { cachedScore = 0; return 0; }
}

void updateFishLED() {
  byte b = currentLedBright;
  byte score = calcFishScore();

  // Гістерезис — не міняємо LED якщо рівень щойно змінився (30 сек затримка)
  static byte lastScore    = 255;
  static uint32_t scoreChangeMs = 0;
  if (score != lastScore) {
    if (scoreChangeMs == 0) {
      scoreChangeMs = millis(); // починаємо відлік
      return; // не міняємо ще
    }
    if (millis() - scoreChangeMs < 30000) return; // чекаємо 30 сек
    lastScore     = score;
    scoreChangeMs = 0;
  } else {
    scoreChangeMs = 0; // скидаємо якщо рівень стабільний
  }

  if (score == 255) {
    setRGB(b, b/2, 0); // жовтий — не визначено
    return;
  }
  switch (score) {
    case 0: setRGB(b, 0, 0); break;  // червоний
    case 1: setRGB(0, 0, b); break;  // синій
    case 2: setRGB(0, b, 0); break;  // зелений
    case 3: break;                   // веселка — в loop
  }
}

// ------------------------- WiFi AP ФУНКЦІЇ -----------------
void drawApBadge() {
  // Без AP:  поз.18=" ", поз.19="S" (або " " якщо немає роутера)
  // З AP:    поз.18="S" (або " "), поз.19="W" (блимає через apTick)
  if (!apActive) {
    lcd.setCursor(18, 3); lcd.print(" ");
    lcd.setCursor(19, 3); lcd.print(staConnected ? "S" : " ");
  } else {
    lcd.setCursor(18, 3); lcd.print(staConnected ? "S" : " ");
    // поз.19 — apTick керує W (блимання); тут не чіпаємо
  }
}

void drawWifiScreen() {
  lcd.clear();
  if (staConnected && !apActive) {
    // ===== Підключено через роутер, AP вимкнена =====
    // Рядок 0: заголовок  (20 символів)
    lcd.setCursor(0, 0); lcd.print(">>Via Router<<   S ");
    // Рядок 1: назва мережі
    lcd.setCursor(0, 1); lcd.print("Net:"); lcd.print(WiFi.SSID().substring(0, 15));
    // Рядок 2: IP адреса
    lcd.setCursor(0, 2); lcd.print("IP:"); lcd.print(WiFi.localIP().toString());
    // Рядок 3: підказка
    lcd.setCursor(0, 3); lcd.print("Use IP^ in browser");
  } else if (staConnected && apActive) {
    // ===== Підключено через роутер І AP активна =====
    lcd.setCursor(0, 0); lcd.print("Router+AP       SW");
    lcd.setCursor(0, 1); lcd.print("R:"); lcd.print(WiFi.localIP().toString());
    lcd.setCursor(0, 2); lcd.print("AP:"); lcd.print(AP_IP);
    lcd.setCursor(0, 3); lcd.print("AP:"); lcd.print(AP_SSID);
  } else if (apActive) {
    // ===== Тільки AP =====
    lcd.setCursor(0, 0); lcd.print(">>  WiFi AP  <<  W");
    lcd.setCursor(0, 1); lcd.print("Net: "); lcd.print(AP_SSID);
    lcd.setCursor(0, 2); lcd.print("Pwd: "); lcd.print(AP_PASS);
    lcd.setCursor(0, 3); lcd.print("IP:  "); lcd.print(AP_IP);
  } else {
    // ===== Не підключено =====
    lcd.setCursor(0, 0); lcd.print(">> No WiFi <<   --");
    lcd.setCursor(0, 1); lcd.print("Hold 3s: start AP");
    lcd.setCursor(0, 2); lcd.print("Saved nets:"); lcd.print(wifiNetCount);
    lcd.setCursor(0, 3); lcd.print("                  ");
  }
}

void startAP() {
  WiFi.mode(WIFI_AP_STA);  // завжди AP+STA — STA підключення не переривається
  WiFi.softAP(AP_SSID, AP_PASS);
  delay(100);  // даємо softAP час ініціалізуватись
  if (!staWebActive) {
    // Сервер ще не запущено — запускаємо
    setupWebServer();
    webServer.begin();
  }
  // якщо вже запущено через STA — просто додаємо AP, сервер продовжує працювати
  apActive = true;
  apManual = true;  // юзер вмикав вручну
  staWebActive = true;  // сервер активний в будь-якому разі
  Serial.println("AP started: " AP_SSID);
}

void stopAP() {
  apActive = false;
  apManual = false;
  WiFi.softAPdisconnect(true);
  if (staConnected) {
    // Лишаємося в STA режимі, сервер продовжує слухати через роутер
    WiFi.mode(WIFI_STA);
    // staWebActive залишається true
    Serial.println("AP stopped, WebServer still active via STA");
  } else if (wifiNetCount > 0) {
    WiFi.mode(WIFI_STA);
    staWebActive = false;
    webServer.stop();
    tryConnectWifi();
    Serial.println("AP stopped, trying STA");
  } else {
    WiFi.mode(WIFI_OFF);
    staWebActive = false;
    webServer.stop();
    Serial.println("AP stopped, WiFi off");
  }
}

void apTick() {
  if (!apActive) return;
  // AP активна: S на поз.18, W блимає на поз.19
  if (millis() - apBlinkTimer >= 1000 && mode == 0) {
    apBlinkTimer = millis();
    apBlink = !apBlink;
    // Перемалюємо обидві позиції щоб S завжди стояла на 18
    lcd.setCursor(18, 3); lcd.print(staConnected ? "S" : " ");
    lcd.setCursor(19, 3); lcd.print(apBlink ? "W" : " ");
  }
}

void setupWebServer() {
  // CORS — дозволяємо доступ з будь-якого пристрою в мережі
  webServer.enableCORS(true);

  // Головна сторінка — gzip стиснений HTML у PROGMEM (60KB→17KB)
static const uint8_t HTML_GZ[] PROGMEM = {
  0x1f, 0x8b, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xff, 0xed, 0xbd, 0xeb, 0x72, 0x1b, 0x57,
  0x76, 0x28, 0xfc, 0x5f, 0x4f, 0xd1, 0xe2, 0xc8, 0x6c, 0xb4, 0x09, 0x80, 0x0d, 0x80, 0x20, 0x21,
  0x80, 0x20, 0xcb, 0x94, 0xe4, 0x91, 0x13, 0x5b, 0xf6, 0x31, 0xe5, 0x28, 0x53, 0x8a, 0x6a, 0xd4,
  0x04, 0x1a, 0x02, 0x22, 0x10, 0xc0, 0x41, 0x37, 0x48, 0xc9, 0x24, 0x52, 0x92, 0x35, 0xb2, 0x3d,
  0x29, 0xc7, 0xf2, 0xd8, 0x1a, 0x39, 0x33, 0xb1, 0x2d, 0xcb, 0x99, 0xcc, 0x4c, 0x7d, 0xc9, 0xa9,
  0x50, 0xb2, 0x65, 0xc9, 0xb2, 0x2e, 0x55, 0x79, 0x80, 0xaf, 0xc0, 0x57, 0xd0, 0x0b, 0x7c, 0xf3,
  0x08, 0xdf, 0x5a, 0x6b, 0xef, 0xdd, 0xbd, 0x77, 0xdf, 0x00, 0xea, 0xe2, 0x78, 0x4e, 0x26, 0x13,
  0x53, 0x8d, 0xee, 0x7d, 0xdf, 0xeb, 0xbe, 0xd7, 0x5e, 0x6b, 0x71, 0xff, 0xe1, 0xd7, 0x0f, 0x1d,
  0xff, 0xd9, 0x1b, 0x47, 0xb4, 0xa6, 0xbb, 0xde, 0x5e, 0x5a, 0xc4, 0xbf, 0x5a, 0xdb, 0xea, 0x9c,
  0xa9, 0xea, 0x83, 0xb3, 0xfa, 0xd2, 0xbe, 0xc5, 0xa6, 0x6d, 0xd5, 0x97, 0x16, 0xd7, 0x6d, 0xd7,
  0xd2, 0x6a, 0x4d, 0xab, 0xef, 0xd8, 0x6e, 0x55, 0x7f, 0xeb, 0xf8, 0xcb, 0x99, 0x92, 0xce, 0xdf,
  0x76, 0xac, 0x75, 0xbb, 0xaa, 0x6f, 0xb4, 0xec, 0xcd, 0x5e, 0xb7, 0xef, 0xea, 0x5a, 0xad, 0xdb,
  0x71, 0xed, 0x0e, 0x94, 0xda, 0x6c, 0xd5, 0xdd, 0x66, 0xb5, 0x6e, 0x6f, 0xb4, 0x6a, 0x76, 0x86,
  0x7e, 0xa4, 0x5b, 0x9d, 0x96, 0xdb, 0xb2, 0xda, 0x19, 0xa7, 0x66, 0xb5, 0xed, 0x6a, 0x0e, 0xdb,
  0x77, 0x5b, 0x6e, 0xdb, 0x5e, 0x1a, 0x7d, 0x39, 0xba, 0x3b, 0xba, 0x39, 0xda, 0x19, 0x7d, 0x3f,
  0xba, 0x37, 0x7a, 0x38, 0xba, 0x3f, 0xba, 0xbd, 0xfb, 0xce, 0xee, 0x85, 0xc5, 0x59, 0xf6, 0x75,
  0xdf, 0xa2, 0xe3, 0x9e, 0xc7, 0x7f, 0x35, 0xed, 0xc5, 0xad, 0x75, 0xab, 0x7f, 0xa6, 0xd5, 0x29,
  0x9b, 0x95, 0x9e, 0x55, 0xaf, 0xb7, 0x3a, 0x67, 0xe0, 0x69, 0xad, 0x7b, 0x2e, 0xe3, 0xb4, 0xde,
  0xc6, 0x1f, 0x6b, 0xdd, 0x7e, 0xdd, 0xee, 0x67, 0xe0, 0xcd, 0x10, 0x4a, 0xaf, 0x75, 0xeb, 0xe7,
  0xb7, 0xd6, 0xac, 0xda, 0xd9, 0x33, 0xfd, 0xee, 0xa0, 0x53, 0x2f, 0xff, 0xc4, 0xb4, 0x72, 0xf3,
  0xf9, 0x52, 0xa5, 0xd6, 0x6d, 0x77, 0xfb, 0xe5, 0x9f, 0xd8, 0xa6, 0x5d, 0x6a, 0x98, 0x95, 0x06,
  0x8c, 0x38, 0xd3, 0xb0, 0xd6, 0x5b, 0xed, 0xf3, 0x65, 0x7d, 0xd5, 0x3e, 0xd3, 0xb5, 0xb5, 0xb7,
  0x5e, 0xd1, 0xd3, 0x8e, 0xd5, 0x71, 0x32, 0x8e, 0xdd, 0x6f, 0x35, 0x2a, 0xeb, 0xad, 0x4e, 0xa6,
  0x69, 0xb7, 0xce, 0x34, 0xdd, 0x72, 0xce, 0x34, 0x37, 0x9a, 0xd8, 0x76, 0x16, 0x57, 0xc6, 0xee,
  0xcb, 0xcd, 0xb7, 0x5b, 0x1d, 0xdb, 0xea, 0x67, 0xce, 0xf4, 0xad, 0x7a, 0x0b, 0x96, 0x20, 0x95,
  0x2b, 0x14, 0xeb, 0xf6, 0x99, 0xf4, 0x4f, 0xcc, 0x7a, 0x61, 0x6d, 0xde, 0x4e, 0xff, 0x24, 0x67,
  0xcd, 0xaf, 0x15, 0x6a, 0x86, 0x37, 0xf2, 0xdc, 0x7c, 0xef, 0x9c, 0x96, 0x37, 0x7b, 0xe7, 0x2a,
  0xf5, 0x96, 0xd3, 0x6b, 0x5b, 0xe7, 0xcb, 0x8d, 0xb6, 0x7d, 0xae, 0x62, 0xb5, 0x5b, 0x67, 0x3a,
  0x99, 0x96, 0x6b, 0xaf, 0x3b, 0xe5, 0x1a, 0xb4, 0x63, 0xf7, 0x2b, 0x67, 0xac, 0x5e, 0x39, 0x97,
  0x87, 0x82, 0xde, 0xfc, 0x5c, 0xb7, 0xbb, 0x5e, 0x86, 0x37, 0x9a, 0xd3, 0x6d, 0xb7, 0xea, 0xda,
  0x4f, 0x72, 0x76, 0xb1, 0x51, 0xb2, 0xa4, 0x81, 0x69, 0xcd, 0xdc, 0x16, 0xcd, 0x0c, 0x56, 0xc6,
  0x2e, 0xe7, 0xb2, 0x73, 0x7d, 0x7b, 0x5d, 0x4c, 0x7c, 0xa1, 0x5e, 0x9f, 0x6b, 0xd4, 0xe4, 0xc2,
  0xd9, 0x46, 0xcb, 0x69, 0x4a, 0xe5, 0xf3, 0x50, 0x9a, 0xbe, 0xbb, 0xd6, 0x9a, 0xb3, 0xa5, 0x0c,
  0x4f, 0x59, 0xcf, 0x7a, 0xde, 0x9c, 0x33, 0x03, 0xa3, 0xca, 0xc9, 0xa3, 0x2a, 0x58, 0xc5, 0x46,
  0xa5, 0xbb, 0x61, 0xf7, 0x1b, 0xed, 0xee, 0x66, 0xe6, 0x5c, 0xd9, 0x1a, 0xb8, 0x5d, 0xd1, 0xf0,
  0x96, 0xb7, 0x10, 0xb0, 0x06, 0x1a, 0xae, 0x46, 0xa5, 0x36, 0xe8, 0x3b, 0x30, 0xc2, 0x5e, 0xb7,
  0x45, 0xf3, 0x16, 0xe3, 0xb5, 0x0e, 0xae, 0xad, 0x15, 0x03, 0xdd, 0x14, 0xbc, 0x6e, 0xdc, 0x3e,
  0x6c, 0x55, 0xcf, 0xea, 0xc3, 0x5a, 0x55, 0xe8, 0x19, 0xa0, 0xac, 0xdb, 0x29, 0x67, 0xf3, 0x4e,
  0x65, 0xb3, 0x09, 0xeb, 0x98, 0x81, 0x8f, 0x35, 0xbb, 0xdc, 0xe9, 0x6e, 0xf6, 0xad, 0x9e, 0xe8,
  0x3c, 0x6b, 0xd5, 0xdc, 0xd6, 0x86, 0xbd, 0xa5, 0x2c, 0x89, 0xe8, 0x22, 0xbc, 0x4e, 0x3d, 0xeb,
  0x8c, 0xed, 0xad, 0x43, 0xa7, 0xdb, 0xb1, 0x95, 0x5d, 0xf4, 0x8a, 0x88, 0x56, 0x45, 0xc9, 0xb5,
  0x76, 0xb7, 0x76, 0x96, 0xbe, 0xd6, 0xac, 0x7e, 0xdd, 0x5f, 0xc9, 0x33, 0xfd, 0x56, 0xbd, 0x82,
  0x7f, 0x32, 0xb0, 0xcd, 0xf0, 0x06, 0x06, 0x09, 0x7d, 0x0e, 0xd6, 0x3b, 0x4e, 0xb9, 0x6f, 0xf7,
  0x6c, 0xcb, 0x4d, 0xe1, 0x42, 0x65, 0x1a, 0x2d, 0x37, 0x0d, 0xc0, 0xb7, 0x6e, 0x9d, 0x4b, 0xe5,
  0x8a, 0xb0, 0x48, 0xe9, 0x5c, 0xa3, 0x6f, 0x18, 0x3e, 0x38, 0x30, 0x64, 0xf0, 0x16, 0x5e, 0x8c,
  0x04, 0xfb, 0xda, 0x8a, 0xdd, 0xa7, 0x88, 0x0d, 0xe2, 0xd3, 0x46, 0xc0, 0x1d, 0x38, 0xac, 0x69,
  0x6f, 0x7a, 0x73, 0xf0, 0xc3, 0xb5, 0xcf, 0xb9, 0x19, 0x82, 0x4b, 0x0e, 0x91, 0x5e, 0x37, 0x5a,
  0x76, 0xc3, 0x6a, 0x2b, 0x80, 0x56, 0x42, 0x40, 0xa3, 0x17, 0x9b, 0x0c, 0x65, 0x16, 0x4c, 0x53,
  0x05, 0x3c, 0x3e, 0xec, 0x32, 0xb4, 0xac, 0x99, 0x52, 0x4b, 0xed, 0x35, 0xb9, 0xa5, 0xec, 0x42,
  0x51, 0x06, 0x59, 0x06, 0x02, 0x34, 0x10, 0xda, 0xe3, 0x46, 0xb7, 0xbf, 0x5e, 0x1e, 0xf4, 0x7a,
  0x76, 0xbf, 0x66, 0x39, 0x76, 0xa5, 0x6d, 0xbb, 0x30, 0x2c, 0xda, 0x69, 0x1c, 0x75, 0xd6, 0x2c,
  0x72, 0x00, 0x66, 0x4d, 0x0f, 0x80, 0xf2, 0xc8, 0x6d, 0x97, 0xe4, 0xb6, 0x8b, 0x56, 0xc9, 0xb2,
  0x8a, 0x54, 0x1a, 0xd1, 0x00, 0xc8, 0x53, 0xb7, 0x6f, 0xef, 0x05, 0xb1, 0xd9, 0xf2, 0x1a, 0x62,
  0x7d, 0x3d, 0xb4, 0x0c, 0xae, 0xeb, 0xbc, 0xbc, 0xae, 0xa5, 0xa8, 0x75, 0x8d, 0xdb, 0x51, 0x7f,
  0x5c, 0x00, 0xbc, 0x48, 0x14, 0x95, 0xc9, 0x84, 0xd7, 0x49, 0x6d, 0x26, 0xaa, 0x15, 0x36, 0x49,
  0x15, 0xe3, 0x43, 0xdb, 0xa6, 0x36, 0x33, 0x17, 0xd1, 0x4c, 0xdd, 0x76, 0x6a, 0xb1, 0x0b, 0xbb,
  0x66, 0xd6, 0x4a, 0xf5, 0x12, 0xdb, 0x06, 0x60, 0x1e, 0x2e, 0xd2, 0xe5, 0x67, 0x06, 0x97, 0xf3,
  0x61, 0xf8, 0xc7, 0xef, 0x82, 0xd6, 0x94, 0x9b, 0xad, 0x7a, 0xdd, 0xee, 0xa8, 0x9d, 0x6b, 0xcd,
  0x42, 0x00, 0xe1, 0xa5, 0xa1, 0x1f, 0xc4, 0x91, 0x87, 0x5b, 0xa4, 0x16, 0x9c, 0x8d, 0x33, 0x19,
  0xa4, 0x1e, 0x5b, 0xc4, 0xc8, 0x90, 0x0b, 0xbc, 0xe0, 0xf7, 0xb4, 0xd1, 0x72, 0x5a, 0x6b, 0x6d,
  0x9b, 0x15, 0xb4, 0xdd, 0x41, 0x2f, 0x83, 0xf3, 0xeb, 0x3d, 0xe7, 0x99, 0x06, 0xbb, 0x4b, 0x9e,
  0x5b, 0x31, 0x69, 0x72, 0xd4, 0x48, 0xbf, 0xbb, 0xb9, 0x35, 0x11, 0x1f, 0x32, 0xc3, 0xc3, 0x31,
  0x83, 0x2d, 0x81, 0x0c, 0xb1, 0x66, 0xb7, 0xb7, 0x14, 0x38, 0xa8, 0x84, 0xc0, 0x04, 0xbb, 0x29,
  0xe7, 0x02, 0x35, 0x5b, 0x9d, 0xde, 0xc0, 0x8d, 0xe2, 0xda, 0x51, 0x6b, 0x87, 0x4c, 0x2f, 0xb0,
  0x76, 0x32, 0x92, 0x21, 0x83, 0xa5, 0xf1, 0xaa, 0x1c, 0xdf, 0xdb, 0x44, 0xf8, 0x12, 0x00, 0x00,
  0x1a, 0xcc, 0x9a, 0xdb, 0x99, 0x04, 0xfd, 0x19, 0x3f, 0x47, 0xf4, 0x2f, 0x5a, 0x85, 0xbc, 0x87,
  0xfe, 0xc4, 0x1d, 0xd4, 0x31, 0x95, 0xfc, 0x21, 0x34, 0x1a, 0x0d, 0x6f, 0x78, 0x25, 0xc1, 0xff,
  0x03, 0x6c, 0x2f, 0x06, 0x28, 0xdd, 0x6e, 0xcf, 0xc3, 0x41, 0x18, 0x62, 0xb9, 0x89, 0x10, 0x38,
  0xc9, 0x40, 0xf3, 0xf9, 0x52, 0x71, 0xce, 0xf2, 0x04, 0x10, 0xb6, 0xe0, 0xae, 0xe5, 0x0e, 0x9c,
  0x58, 0x7a, 0x3b, 0x57, 0xb3, 0x1a, 0x45, 0x53, 0xee, 0x59, 0x10, 0x11, 0x17, 0xf8, 0x6c, 0x3d,
  0x03, 0xe0, 0x2d, 0x4a, 0x36, 0x6a, 0x85, 0xc6, 0xc2, 0x50, 0x7c, 0xa8, 0x77, 0xc4, 0x07, 0xbb,
  0x51, 0x2c, 0x14, 0x4d, 0xef, 0x43, 0xf7, 0xac, 0xf8, 0x30, 0x3f, 0xbf, 0xb6, 0x36, 0xcf, 0x64,
  0x15, 0x1c, 0x69, 0x37, 0x13, 0xe6, 0x57, 0xf1, 0x3b, 0x1e, 0x81, 0x2d, 0x25, 0x69, 0xc7, 0x71,
  0x49, 0x89, 0x65, 0x45, 0x4b, 0x12, 0x71, 0x90, 0x38, 0x09, 0xe0, 0x23, 0x60, 0xa9, 0xe2, 0x45,
  0x60, 0x0a, 0x82, 0xf9, 0x47, 0x09, 0x11, 0x01, 0x0e, 0x18, 0x20, 0x0d, 0xd6, 0x5c, 0x70, 0x39,
  0x38, 0x1a, 0xc8, 0x12, 0x07, 0x5b, 0xfd, 0xee, 0x99, 0x33, 0x6d, 0x9b, 0xd1, 0xa2, 0x31, 0x83,
  0x96, 0xca, 0x6f, 0xf5, 0xba, 0x7c, 0xd4, 0x7d, 0x1b, 0x84, 0x0d, 0x18, 0xa4, 0x37, 0xe3, 0x56,
  0x07, 0xa1, 0x26, 0x43, 0x82, 0x0a, 0x47, 0x8c, 0x39, 0x5c, 0x3f, 0x2e, 0xef, 0xe6, 0x05, 0xc0,
  0xb1, 0x86, 0xf8, 0xb0, 0xba, 0xc8, 0x66, 0xdd, 0xf3, 0x65, 0x81, 0x4a, 0xa6, 0x28, 0xce, 0xd8,
  0xb9, 0x03, 0x7b, 0x05, 0x90, 0xe9, 0x75, 0x0a, 0x32, 0x24, 0x08, 0x37, 0xae, 0x1d, 0xdc, 0x94,
  0x56, 0x07, 0xd0, 0x1e, 0x05, 0x78, 0x69, 0x35, 0x22, 0x77, 0x38, 0x3f, 0x17, 0x58, 0xfb, 0x82,
  0x23, 0x75, 0x54, 0x5e, 0xb3, 0x1b, 0xc8, 0xcc, 0xb8, 0xea, 0x51, 0xd6, 0xf5, 0x4a, 0xb8, 0x6b,
  0x8e, 0xf3, 0x25, 0x7f, 0x6a, 0xf4, 0xdc, 0xb6, 0x1b, 0x2e, 0x8a, 0x92, 0x15, 0x5f, 0xaa, 0x54,
  0x86, 0xc3, 0x64, 0x83, 0xc0, 0x70, 0x8a, 0x40, 0xfd, 0x23, 0x46, 0x23, 0x2f, 0x51, 0xb9, 0xd6,
  0xb4, 0x6b, 0x67, 0xed, 0xfa, 0x8c, 0x58, 0x0c, 0x65, 0x8e, 0x84, 0x87, 0x63, 0xeb, 0x88, 0x79,
  0xf9, 0xf2, 0x0e, 0x3d, 0xa1, 0xb4, 0xf8, 0xb7, 0x29, 0xa4, 0x1b, 0x86, 0x32, 0x54, 0xa0, 0x2c,
  0xc3, 0x7d, 0x8b, 0xb3, 0x4c, 0x57, 0x5a, 0x9c, 0x25, 0xcd, 0x6d, 0xdf, 0x22, 0xea, 0x40, 0xf0,
  0x4f, 0xbd, 0xb5, 0xa1, 0xd5, 0xda, 0x96, 0xe3, 0x54, 0x75, 0x26, 0xf2, 0x83, 0xfe, 0x06, 0xc2,
  0x52, 0x47, 0xbc, 0x44, 0x9e, 0xae, 0x2f, 0xfd, 0xe9, 0xfa, 0x87, 0xff, 0x0a, 0x2d, 0xc0, 0xfb,
  0x25, 0xac, 0x01, 0xfa, 0x60, 0x2e, 0x56, 0x37, 0x83, 0x4f, 0xd4, 0x2a, 0xf5, 0x07, 0x0d, 0xc4,
  0x10, 0x12, 0xb6, 0x80, 0xfa, 0xd2, 0xab, 0x00, 0x74, 0x8b, 0xb3, 0xd4, 0xa8, 0xf4, 0x57, 0x19,
  0x18, 0xea, 0x1a, 0x3a, 0x6a, 0x79, 0x81, 0x97, 0x1a, 0xc3, 0x2b, 0x5d, 0xeb, 0x76, 0x6a, 0xed,
  0x56, 0xed, 0x6c, 0x75, 0xca, 0x69, 0x76, 0x37, 0x8f, 0x5b, 0x6b, 0x29, 0xbd, 0x6e, 0xb9, 0x96,
  0x6e, 0x4c, 0xc1, 0xc0, 0x3f, 0xf9, 0x47, 0x6d, 0x74, 0x15, 0x46, 0xf9, 0x60, 0xf7, 0x1a, 0x6f,
  0x3a, 0xd4, 0x4e, 0x54, 0x03, 0x24, 0x1a, 0x38, 0xbc, 0x89, 0xf7, 0xb5, 0xd1, 0x27, 0xbb, 0x17,
  0x46, 0x3b, 0xbb, 0xbf, 0xd8, 0xbd, 0x06, 0x93, 0xbd, 0xbb, 0x97, 0x86, 0x70, 0xa7, 0x40, 0x12,
  0x75, 0x59, 0x53, 0x1f, 0xfc, 0x4e, 0x1b, 0x5d, 0x87, 0xa6, 0x1e, 0x8e, 0xbe, 0x1e, 0x3d, 0x80,
  0xbf, 0x77, 0xf6, 0xd2, 0x14, 0xf1, 0x42, 0x6c, 0xe7, 0xf1, 0x6f, 0x7f, 0xf3, 0xff, 0xdd, 0xbd,
  0xa2, 0x8d, 0x3e, 0xa7, 0xd5, 0xdf, 0xd9, 0x7d, 0x7f, 0xf7, 0x9d, 0xec, 0x5e, 0x1a, 0xda, 0x6c,
  0x35, 0x5a, 0x7c, 0x6a, 0xdf, 0x6a, 0x27, 0x5a, 0x2f, 0xb7, 0xc4, 0xa2, 0x4b, 0x6b, 0xdf, 0xaa,
  0x57, 0xd9, 0x2a, 0x8a, 0xb6, 0x50, 0x8d, 0x11, 0x2b, 0xee, 0xf5, 0x83, 0xa5, 0x1a, 0xb5, 0x13,
  0x56, 0xbf, 0xa3, 0x2f, 0xa9, 0x23, 0xc0, 0x2f, 0xc0, 0x4b, 0xfa, 0x30, 0xe4, 0xb8, 0xcf, 0xbe,
  0xbc, 0x88, 0x32, 0x98, 0x2e, 0x83, 0x1c, 0x7b, 0x1d, 0xd9, 0x26, 0x7e, 0x28, 0x34, 0xa9, 0x46,
  0xdc, 0xe7, 0x63, 0xf5, 0xb8, 0xcf, 0xdd, 0x5e, 0x2f, 0x43, 0xed, 0xc7, 0x7c, 0xdf, 0x04, 0x15,
  0xab, 0x09, 0x08, 0x0d, 0x3a, 0x61, 0x5c, 0x91, 0x26, 0xd0, 0xa8, 0xb8, 0x6f, 0x0d, 0x58, 0x9f,
  0x6e, 0xdf, 0x89, 0xfa, 0xcc, 0x27, 0x47, 0xea, 0x9e, 0x4e, 0x85, 0xd9, 0xe3, 0x52, 0xcc, 0xda,
  0x73, 0x00, 0x94, 0x57, 0x3f, 0x84, 0x03, 0x9e, 0xfc, 0x0a, 0xad, 0x34, 0x0b, 0xb0, 0x9d, 0x1f,
  0x5d, 0xd7, 0x46, 0xbf, 0x1d, 0x7d, 0xbf, 0xfb, 0x01, 0x80, 0xd6, 0x2d, 0xed, 0xf1, 0x85, 0xab,
  0xda, 0xe8, 0xce, 0x68, 0x47, 0x1b, 0x7d, 0x33, 0xba, 0x0d, 0x08, 0xf0, 0x01, 0x20, 0x67, 0x61,
  0xc9, 0xef, 0xe1, 0x65, 0xc4, 0x6d, 0xd1, 0x96, 0x90, 0x64, 0x75, 0x15, 0x0f, 0xc7, 0x74, 0xf8,
  0xc1, 0x0d, 0x6d, 0xf4, 0x15, 0x34, 0x7e, 0x7f, 0xf4, 0x08, 0xf0, 0x1f, 0x51, 0xe4, 0x9d, 0xdd,
  0x4b, 0xf8, 0x2f, 0xeb, 0xfc, 0x11, 0x01, 0xfa, 0x43, 0xe8, 0xff, 0x2e, 0x80, 0x3b, 0x00, 0x7c,
  0x60, 0x04, 0xc7, 0x41, 0xc9, 0x7d, 0xca, 0x11, 0x7c, 0xfc, 0x07, 0x6d, 0xf4, 0x31, 0x74, 0xf1,
  0x3d, 0x76, 0xb5, 0x7b, 0x6d, 0xf7, 0x22, 0x8c, 0xe0, 0x83, 0xc9, 0x7a, 0x3f, 0x3a, 0x58, 0x7f,
  0xda, 0xe9, 0xff, 0x07, 0x4e, 0xff, 0xee, 0xee, 0xc5, 0xd1, 0xbd, 0xc9, 0xba, 0x7c, 0xa3, 0x6f,
  0x3b, 0xce, 0xd1, 0x67, 0xdd, 0x6b, 0xc2, 0x1e, 0x53, 0x87, 0x87, 0xc7, 0x75, 0x18, 0x04, 0x3e,
  0x8f, 0x68, 0x25, 0x82, 0x9f, 0xa4, 0x64, 0xe8, 0x82, 0xdc, 0x87, 0x55, 0x09, 0xaa, 0xc6, 0x2b,
  0xf2, 0x42, 0xe3, 0xa4, 0xaa, 0xbf, 0x1f, 0x38, 0x6e, 0xab, 0x71, 0x3e, 0x23, 0x18, 0x37, 0xd9,
  0x69, 0x32, 0x6b, 0xb6, 0xbb, 0x69, 0xdb, 0x1d, 0xd2, 0x0e, 0x68, 0x12, 0x65, 0xfc, 0x43, 0x22,
  0x58, 0xc9, 0xeb, 0x86, 0x75, 0x24, 0x9e, 0xd5, 0x6e, 0x93, 0x65, 0x3d, 0x9d, 0x13, 0xb3, 0x55,
  0x12, 0x80, 0xf5, 0xa5, 0xd1, 0xa7, 0x40, 0x5d, 0x6f, 0x11, 0xe7, 0x78, 0x07, 0xfe, 0x7e, 0x8b,
  0xcb, 0x0b, 0xcf, 0x57, 0xb2, 0x59, 0x9f, 0xd6, 0x52, 0x0f, 0xca, 0x8f, 0xb8, 0x59, 0xf2, 0x51,
  0x06, 0x06, 0xaf, 0x4b, 0x03, 0x5d, 0x1b, 0xc0, 0x92, 0x79, 0x7c, 0x17, 0xe4, 0x78, 0x9f, 0x72,
  0xeb, 0xce, 0xf9, 0x4e, 0xed, 0x58, 0x77, 0x33, 0x65, 0xb0, 0x41, 0xe2, 0xcf, 0x15, 0x28, 0x80,
  0xb0, 0xf0, 0x91, 0x36, 0xba, 0x81, 0xc0, 0xb6, 0x7b, 0x99, 0xd8, 0x0a, 0xb0, 0xb9, 0xd1, 0x9d,
  0xdd, 0x4b, 0x38, 0x70, 0x18, 0x36, 0x70, 0x2a, 0xd6, 0xec, 0xd2, 0xbe, 0xf0, 0x68, 0xe5, 0x47,
  0x79, 0x57, 0xd9, 0xfc, 0xbd, 0x8e, 0xc4, 0x7a, 0xf8, 0xb0, 0x19, 0x26, 0x7b, 0xb5, 0xc3, 0xd6,
  0xf9, 0x78, 0x52, 0xc6, 0xf8, 0xd6, 0xc4, 0xa0, 0xc4, 0x87, 0x44, 0xa0, 0xfe, 0xe1, 0x7f, 0x6a,
  0xa3, 0x5f, 0xc1, 0xea, 0xdf, 0x41, 0x82, 0x06, 0xd3, 0xfc, 0x4e, 0xc3, 0x59, 0x11, 0xe4, 0x8f,
  0xee, 0x13, 0xb6, 0xbf, 0x0b, 0xfb, 0x72, 0x6b, 0xf4, 0x90, 0xf0, 0xfe, 0x1a, 0x01, 0x7f, 0x08,
  0xdc, 0x92, 0x45, 0x90, 0x80, 0xce, 0x4a, 0xa0, 0x84, 0xe8, 0x45, 0xb8, 0x0c, 0x2d, 0x6b, 0x0b,
  0xf9, 0x52, 0x66, 0xa1, 0x90, 0x87, 0x0e, 0x47, 0xf7, 0xb5, 0xdd, 0x0b, 0xc0, 0x6b, 0xb1, 0xb3,
  0xac, 0x06, 0x00, 0x72, 0x93, 0x88, 0xde, 0xed, 0xd1, 0xb7, 0x30, 0x14, 0x24, 0x3b, 0x80, 0x84,
  0xb7, 0x10, 0x17, 0xef, 0x00, 0xa8, 0xec, 0xec, 0xbe, 0x27, 0x40, 0x46, 0xdb, 0xbd, 0xa6, 0x71,
  0x02, 0x89, 0xa4, 0xf2, 0x2e, 0xc8, 0x10, 0x3b, 0xa3, 0xef, 0x60, 0x26, 0xb7, 0x35, 0xa4, 0x97,
  0xf0, 0xea, 0x26, 0xd0, 0xaf, 0xdb, 0xb4, 0x81, 0xf7, 0xb3, 0xc1, 0x7d, 0x49, 0x02, 0xa7, 0xd0,
  0xd8, 0x15, 0x74, 0x22, 0x60, 0x03, 0x1d, 0x4b, 0x8f, 0x02, 0x4f, 0xa6, 0x64, 0xc3, 0xa6, 0x91,
  0x4a, 0x3e, 0xe1, 0x5a, 0x29, 0xf6, 0xcb, 0x40, 0xef, 0x05, 0x5a, 0xb9, 0x1b, 0x48, 0x89, 0x77,
  0xdf, 0xd1, 0x5e, 0xd2, 0x52, 0x81, 0x05, 0x33, 0x16, 0x67, 0xa9, 0xab, 0x89, 0x70, 0x65, 0xae,
  0x17, 0x45, 0x19, 0xfc, 0x89, 0x90, 0x60, 0xac, 0xb9, 0xe7, 0x7b, 0x50, 0xb9, 0x33, 0x58, 0x5f,
  0x83, 0x6f, 0x04, 0x6b, 0x3d, 0xa4, 0x77, 0x2f, 0xe9, 0xda, 0x7a, 0xab, 0x53, 0xd5, 0x4d, 0xf8,
  0xd7, 0x3a, 0x57, 0xd5, 0x4b, 0xa6, 0x89, 0x04, 0xca, 0xee, 0xc1, 0xab, 0x6c, 0x51, 0xd7, 0x36,
  0xac, 0xf6, 0xc0, 0xc6, 0xcf, 0x1e, 0xf6, 0x29, 0x6b, 0x52, 0x79, 0x36, 0x46, 0x86, 0x85, 0x68,
  0x23, 0x43, 0x50, 0x89, 0x8f, 0x3c, 0xa5, 0xf0, 0x27, 0xca, 0xc9, 0x82, 0x47, 0x0a, 0x50, 0xfc,
  0x20, 0xa2, 0x9e, 0x32, 0x39, 0x35, 0xc0, 0x37, 0x40, 0x0d, 0x60, 0xd2, 0x64, 0x01, 0xac, 0xea,
  0x20, 0x61, 0x5e, 0x03, 0x48, 0xbc, 0x47, 0x78, 0x73, 0x8f, 0xe0, 0x11, 0x20, 0x90, 0xe8, 0x18,
  0xc2, 0xd8, 0x03, 0x92, 0xd4, 0x2f, 0x71, 0x86, 0x85, 0x45, 0x71, 0x7b, 0x88, 0xd8, 0xdd, 0x25,
  0x28, 0x06, 0xf4, 0x62, 0xa0, 0xfa, 0x0d, 0x91, 0x13, 0x19, 0xe7, 0x90, 0xac, 0xbc, 0x0f, 0xfb,
  0xfb, 0x69, 0x24, 0xfa, 0x31, 0x4e, 0xb4, 0xa0, 0xf1, 0x8a, 0xb7, 0x7c, 0x1c, 0x81, 0x5f, 0x5f,
  0x33, 0x8a, 0xa4, 0x01, 0x5a, 0xdc, 0xd5, 0xf0, 0x3b, 0x1b, 0x00, 0x76, 0x0a, 0x9f, 0x41, 0x86,
  0xbd, 0xb4, 0x7b, 0x95, 0xa1, 0xc4, 0x45, 0x18, 0x0b, 0xb4, 0x9e, 0x0d, 0x6d, 0x4f, 0x58, 0x3b,
  0xde, 0xcb, 0xbe, 0xa8, 0x9a, 0xb6, 0x6c, 0x0a, 0x2a, 0x25, 0x9a, 0x5a, 0xc8, 0x8c, 0x1a, 0x3e,
  0x30, 0x60, 0xd4, 0x77, 0xd9, 0xa7, 0xb0, 0x32, 0x81, 0x8d, 0x65, 0x0a, 0xcf, 0x19, 0xeb, 0x56,
  0xfe, 0x1b, 0xb1, 0x6e, 0xe5, 0x7f, 0x04, 0xd6, 0xe5, 0x54, 0xac, 0x5b, 0xf9, 0x0b, 0xd6, 0xfd,
  0x28, 0xb1, 0x6e, 0x12, 0x26, 0xba, 0x37, 0x43, 0xb6, 0x0f, 0x1c, 0x64, 0x1f, 0x09, 0x63, 0x6e,
  0xc4, 0x11, 0x07, 0x60, 0xe6, 0x47, 0xa3, 0x7b, 0xb8, 0x01, 0xb0, 0xe2, 0x0f, 0x50, 0x7e, 0x29,
  0x73, 0x33, 0x4a, 0x00, 0xd0, 0x3c, 0x24, 0x5a, 0x6d, 0x77, 0xdd, 0x97, 0x56, 0x54, 0xe1, 0x6f,
  0xb3, 0xe5, 0xd6, 0x9a, 0x6f, 0x88, 0xaf, 0x44, 0xf7, 0xc5, 0xd6, 0xc4, 0xa2, 0x41, 0x31, 0xe6,
  0xe4, 0x54, 0x1e, 0x6f, 0x9e, 0x21, 0x82, 0x7a, 0x36, 0xe5, 0x6f, 0x65, 0xec, 0xf9, 0xb8, 0x98,
  0xdb, 0x4b, 0xa1, 0x5d, 0x88, 0x9a, 0xcd, 0x4a, 0xf2, 0x6c, 0x72, 0x3f, 0x96, 0xd9, 0xac, 0x84,
  0x66, 0x43, 0xfb, 0xec, 0x0b, 0x15, 0x64, 0xfa, 0x78, 0x15, 0x69, 0xa9, 0x1e, 0xb5, 0xfb, 0xa1,
  0x73, 0x74, 0x94, 0x87, 0xfd, 0xbd, 0xde, 0x8b, 0x54, 0x17, 0xd0, 0x70, 0x42, 0xa7, 0x6d, 0x21,
  0x3a, 0x15, 0xad, 0x34, 0x58, 0x1b, 0xb6, 0xb7, 0xce, 0x0e, 0xe8, 0x0e, 0xa8, 0x2d, 0x3f, 0x94,
  0xc5, 0xd6, 0xaf, 0x89, 0x34, 0x8c, 0x6e, 0x01, 0x29, 0xb8, 0x04, 0x04, 0xe2, 0xc1, 0xee, 0x25,
  0x75, 0x0d, 0xe4, 0x31, 0x8f, 0xeb, 0x69, 0xd5, 0x76, 0x5d, 0xd8, 0x2a, 0xec, 0x27, 0xa0, 0x0b,
  0xf2, 0xe3, 0x09, 0xd1, 0xbd, 0x6c, 0xb4, 0x02, 0x3e, 0x45, 0x46, 0xc4, 0xbb, 0xb3, 0xd0, 0xfd,
  0x0e, 0x90, 0xb3, 0xe0, 0x00, 0x62, 0xf4, 0x12, 0x06, 0x5c, 0xc9, 0x8a, 0xc9, 0x18, 0xcd, 0x02,
  0x4d, 0x25, 0x24, 0xe5, 0x7b, 0x63, 0x88, 0x56, 0x1e, 0x9e, 0x72, 0x83, 0x18, 0x9b, 0xe7, 0x63,
  0xf1, 0xcd, 0xf8, 0x6c, 0x1a, 0x7d, 0x33, 0x12, 0x92, 0x10, 0x92, 0x61, 0x5a, 0x32, 0xb3, 0xa5,
  0x9a, 0x3a, 0x77, 0xaa, 0x21, 0x9b, 0xac, 0xcf, 0x4e, 0x71, 0x1f, 0x9a, 0x56, 0xe7, 0x8c, 0x8d,
  0x93, 0x6d, 0xdb, 0x35, 0x17, 0xed, 0x3a, 0x48, 0x25, 0x96, 0x34, 0xa0, 0x95, 0x8f, 0xb4, 0xd1,
  0x67, 0x48, 0xec, 0x51, 0x23, 0xc1, 0xad, 0xbe, 0xb8, 0x7b, 0x25, 0x28, 0x11, 0x24, 0x8f, 0x31,
  0xf7, 0xf4, 0x63, 0xcc, 0xc5, 0x8c, 0x31, 0xc7, 0xc6, 0xf8, 0xfb, 0xf7, 0xb5, 0xd1, 0xbf, 0xc1,
  0x1e, 0x7c, 0x3b, 0xda, 0x51, 0x86, 0x16, 0x44, 0x19, 0xda, 0x79, 0x1b, 0x78, 0x41, 0x63, 0xd0,
  0x5e, 0x1d, 0xac, 0xe9, 0xb1, 0x5b, 0x34, 0x3f, 0x6e, 0x8b, 0xe6, 0xd5, 0x93, 0xa1, 0x78, 0xd1,
  0x43, 0x3e, 0x4a, 0x8a, 0x3b, 0x75, 0x1a, 0xcb, 0x18, 0x16, 0xf2, 0x61, 0x91, 0x4e, 0x3a, 0x2f,
  0x8e, 0x80, 0x9e, 0xe0, 0xbe, 0x09, 0x9e, 0x3d, 0xba, 0x09, 0x3c, 0xfb, 0x02, 0x7b, 0xfc, 0x66,
  0xf7, 0x52, 0x90, 0x99, 0x24, 0x6f, 0x64, 0xfe, 0xe9, 0x37, 0x32, 0x1f, 0xb3, 0x91, 0x79, 0xb6,
  0x91, 0xcc, 0xfc, 0xb8, 0x43, 0x76, 0xc0, 0x8b, 0x68, 0x8a, 0xda, 0x0b, 0x9c, 0x15, 0x9e, 0x7e,
  0x78, 0x85, 0x98, 0xe1, 0x15, 0xf8, 0xf0, 0xbe, 0xc4, 0xe1, 0x3d, 0x24, 0x35, 0xfb, 0xd1, 0xde,
  0x06, 0x37, 0xf7, 0xf4, 0x83, 0x9b, 0x8b, 0x19, 0xdc, 0x1c, 0x1f, 0xdc, 0x0d, 0x18, 0xdc, 0xcc,
  0xe8, 0xb7, 0x78, 0x84, 0xb2, 0x97, 0x91, 0x15, 0x9f, 0x7e, 0x64, 0xc5, 0x98, 0x91, 0x15, 0x7d,
  0x12, 0xf2, 0x31, 0xd2, 0x0d, 0xb4, 0x80, 0x70, 0x88, 0x4c, 0xc4, 0xd3, 0x09, 0x4f, 0x7e, 0xf8,
  0xfc, 0x64, 0x88, 0xd1, 0xb0, 0xed, 0xd1, 0x77, 0x08, 0xe6, 0x68, 0xc5, 0xde, 0x7d, 0x1f, 0xe4,
  0x56, 0x60, 0x4d, 0xef, 0x00, 0xc3, 0xb8, 0xcb, 0xed, 0x3f, 0x20, 0xe5, 0x3e, 0xf4, 0x44, 0xe3,
  0xdd, 0x4b, 0x59, 0xb1, 0x6a, 0x5a, 0x15, 0xe5, 0x60, 0x14, 0x8f, 0xdf, 0x47, 0x9b, 0x1d, 0x12,
  0xbb, 0x7b, 0x52, 0xc3, 0x28, 0x26, 0xdf, 0x13, 0x7b, 0x9f, 0x55, 0x87, 0xbd, 0x27, 0xbe, 0xf1,
  0xc1, 0x3f, 0x69, 0xa3, 0x3f, 0x60, 0xa3, 0x9e, 0x45, 0x0a, 0x0d, 0x45, 0xbb, 0x57, 0x76, 0x2f,
  0x3e, 0x33, 0xe3, 0xd3, 0x47, 0x40, 0xa6, 0xdf, 0x19, 0x3d, 0x2c, 0x6b, 0x47, 0xde, 0xd2, 0x0e,
  0xaf, 0x1e, 0xd7, 0x52, 0x6f, 0x1d, 0x3f, 0x34, 0x93, 0xc7, 0xe9, 0xdd, 0x85, 0x1d, 0xd8, 0xd1,
  0x66, 0x35, 0x7c, 0x51, 0xd0, 0x60, 0x89, 0xae, 0x61, 0x41, 0x03, 0x16, 0xe1, 0xba, 0x6a, 0x5d,
  0x42, 0xa1, 0x1e, 0xd6, 0x8f, 0x36, 0xed, 0x96, 0xc6, 0x34, 0x05, 0x5a, 0x96, 0x07, 0xbb, 0x1f,
  0xe2, 0x22, 0x83, 0x96, 0x41, 0x4b, 0x0c, 0x3f, 0x84, 0x30, 0x70, 0xc7, 0xb3, 0x54, 0x7d, 0x8b,
  0x53, 0x83, 0xf2, 0x68, 0xec, 0x7c, 0x66, 0x62, 0x0b, 0x4e, 0x8d, 0x20, 0xd6, 0x7d, 0xfb, 0xa7,
  0xd2, 0xa2, 0x8e, 0x83, 0x6f, 0xf7, 0x6d, 0x33, 0x09, 0x8e, 0xdd, 0xb7, 0xe3, 0x18, 0xa1, 0x7b,
  0xfc, 0x6d, 0xc1, 0x03, 0xaf, 0xfe, 0x42, 0x13, 0x6b, 0xaa, 0xa5, 0xd8, 0x9a, 0x1a, 0x7b, 0x42,
  0x32, 0xf7, 0xed, 0xdc, 0x84, 0x83, 0xc8, 0x85, 0x07, 0x41, 0x4c, 0xee, 0xf1, 0xe7, 0xbf, 0xc0,
  0x13, 0x3b, 0xb6, 0x91, 0x29, 0xb1, 0x93, 0x7b, 0x1d, 0x45, 0x7e, 0xc2, 0x51, 0xe4, 0xc3, 0xa3,
  0x20, 0x0a, 0xfd, 0xf8, 0x9f, 0x2f, 0x88, 0x51, 0x14, 0x60, 0x14, 0x02, 0x7c, 0x12, 0x91, 0x39,
  0x42, 0xfa, 0x72, 0xdf, 0x7e, 0x3a, 0xd1, 0xeb, 0xd7, 0x1f, 0x21, 0x41, 0x41, 0xcc, 0xbc, 0xcc,
  0x2c, 0xd5, 0xc2, 0x4a, 0xca, 0x65, 0x40, 0xc2, 0xf1, 0x78, 0x89, 0x2c, 0x46, 0xe8, 0xe6, 0x66,
  0xfd, 0xb0, 0xe2, 0x56, 0x21, 0x47, 0x06, 0x71, 0xb8, 0x9f, 0x55, 0x28, 0x0f, 0x9e, 0x1b, 0x81,
  0x72, 0x0c, 0xa3, 0x00, 0x74, 0xb8, 0x0f, 0x98, 0xf3, 0x80, 0x6c, 0xb6, 0x0f, 0x85, 0x9a, 0x2e,
  0x9d, 0xd4, 0x22, 0xfd, 0xe0, 0x27, 0x6b, 0x38, 0xc4, 0x5b, 0x6c, 0x02, 0xec, 0xe7, 0xee, 0x55,
  0x3e, 0x78, 0x6f, 0xe8, 0x80, 0x92, 0xfc, 0x7c, 0x9c, 0xd5, 0xfb, 0x10, 0x8a, 0x00, 0xbd, 0xc2,
  0x3a, 0xbf, 0x04, 0x6d, 0x9b, 0x55, 0x87, 0x59, 0xbf, 0x0b, 0x08, 0x87, 0x38, 0x77, 0x0b, 0xfe,
  0x77, 0x1b, 0x2d, 0xc6, 0xa8, 0x96, 0xa7, 0x35, 0x3a, 0xca, 0xba, 0x00, 0xa4, 0x0c, 0x8b, 0x62,
  0xff, 0x40, 0x07, 0x45, 0x41, 0x7e, 0xd0, 0x03, 0xa3, 0x46, 0xa5, 0xfd, 0x11, 0xfc, 0x42, 0x3a,
  0x98, 0xb4, 0x79, 0x92, 0x73, 0x48, 0x0c, 0xda, 0xb1, 0x12, 0x01, 0xf0, 0x22, 0xb7, 0x03, 0x3a,
  0x99, 0xc5, 0x5d, 0x1f, 0x38, 0xf6, 0xf1, 0xd6, 0xba, 0xad, 0x80, 0x96, 0x2a, 0xf7, 0xab, 0x9e,
  0x03, 0xcc, 0x57, 0xc1, 0x53, 0x82, 0x82, 0xa0, 0x2e, 0xcb, 0x4a, 0x7c, 0xcf, 0xc8, 0xe7, 0x22,
  0x17, 0x70, 0xbe, 0x52, 0xb4, 0x6a, 0xa1, 0x58, 0x09, 0xf0, 0x61, 0xab, 0x2f, 0x0e, 0x3b, 0x82,
  0x7b, 0x10, 0xa9, 0x7e, 0xed, 0x4d, 0x49, 0xf8, 0x57, 0xd4, 0x57, 0x88, 0x3e, 0x12, 0x05, 0x95,
  0x48, 0x3e, 0x33, 0xaf, 0x3c, 0x1c, 0x7d, 0xf3, 0xdf, 0x0f, 0xa4, 0xd7, 0x46, 0xdf, 0x78, 0x53,
  0x7f, 0xe0, 0x8f, 0x16, 0xe0, 0x23, 0xc5, 0x24, 0x45, 0x02, 0x9c, 0x6f, 0xf8, 0x22, 0xa1, 0xb5,
  0x08, 0x4f, 0x1b, 0x50, 0xdc, 0x66, 0x87, 0x16, 0xb7, 0x58, 0x0b, 0x68, 0xa5, 0x78, 0x84, 0x40,
  0xc5, 0xf5, 0x21, 0x43, 0x82, 0x78, 0x76, 0xa4, 0x01, 0x22, 0x3a, 0xb3, 0x17, 0x31, 0xd6, 0x02,
  0x60, 0xba, 0x23, 0x2c, 0x52, 0x57, 0x00, 0x92, 0x3f, 0xa0, 0xc1, 0x00, 0x4c, 0x7e, 0x8f, 0x6c,
  0x47, 0x1d, 0x09, 0x0d, 0xf5, 0x01, 0x99, 0xad, 0x6e, 0x13, 0x37, 0xbf, 0xc7, 0x16, 0xf2, 0x26,
  0x9d, 0x59, 0x5d, 0x82, 0xa1, 0xa7, 0x90, 0xef, 0xec, 0x5e, 0x40, 0x66, 0xf6, 0x05, 0xd9, 0xa6,
  0xae, 0x92, 0xed, 0x0c, 0x97, 0xfc, 0x81, 0x34, 0xfe, 0xb2, 0xb6, 0xfb, 0x4b, 0x58, 0x0a, 0x32,
  0xb0, 0x21, 0x5a, 0xe1, 0xa8, 0xbf, 0xcb, 0x48, 0x5c, 0x8c, 0x90, 0x23, 0xad, 0x70, 0xff, 0x59,
  0x9f, 0xf5, 0xe3, 0x81, 0xcb, 0x05, 0xb2, 0xba, 0x51, 0xb9, 0x0c, 0x8d, 0xe5, 0x11, 0xfb, 0xf1,
  0x83, 0xe0, 0xd0, 0x6a, 0xcf, 0xda, 0xec, 0xfc, 0x98, 0x91, 0x48, 0xde, 0xb8, 0x24, 0x03, 0x06,
  0x9d, 0xec, 0xe1, 0x64, 0xd0, 0xbd, 0x03, 0x06, 0x1f, 0x52, 0xc7, 0xc8, 0xdf, 0x51, 0xb2, 0x01,
  0x84, 0xdc, 0xf1, 0xf2, 0x01, 0xcd, 0x2b, 0x6f, 0xe5, 0x2c, 0x33, 0xca, 0x17, 0xb6, 0xb4, 0x56,
  0xf4, 0x3f, 0xc8, 0x2a, 0x99, 0x2c, 0x5c, 0xc9, 0x68, 0xd6, 0x68, 0xac, 0x2d, 0xcc, 0xf9, 0xc7,
  0x5e, 0x8f, 0x7f, 0xfb, 0x25, 0xf9, 0xcb, 0x7c, 0xca, 0x40, 0x02, 0x69, 0xf9, 0x83, 0x31, 0x58,
  0xbd, 0x5f, 0x1b, 0xfd, 0x8b, 0x00, 0xfc, 0x1d, 0x84, 0x52, 0x76, 0xba, 0xca, 0x11, 0x8f, 0x5e,
  0xde, 0xa3, 0x17, 0x78, 0x62, 0x27, 0x3b, 0x5d, 0x50, 0x03, 0x68, 0x00, 0x7e, 0xe8, 0xe1, 0x0c,
  0x55, 0x82, 0x0e, 0x9e, 0x4a, 0xec, 0xfc, 0xb5, 0x36, 0xfa, 0x1d, 0x99, 0x96, 0x15, 0x94, 0xbb,
  0xf2, 0xbc, 0xa9, 0xcf, 0xe7, 0x61, 0x94, 0xbd, 0x05, 0xeb, 0x44, 0xf2, 0xb8, 0x26, 0xc4, 0x6c,
  0x89, 0x48, 0x08, 0xd2, 0x42, 0xab, 0xc4, 0x09, 0xcb, 0x2f, 0x68, 0xdc, 0x77, 0x95, 0x71, 0x67,
  0xb1, 0x69, 0x6f, 0xe1, 0x65, 0x1a, 0xc2, 0xce, 0x4a, 0x19, 0xda, 0x5f, 0x61, 0x68, 0xff, 0x21,
  0xa3, 0x53, 0x0f, 0x98, 0x94, 0x4a, 0x27, 0xab, 0x0f, 0xc4, 0x8e, 0x21, 0x0d, 0x00, 0xe2, 0x31,
  0x33, 0xa7, 0x71, 0x67, 0x34, 0xa4, 0x70, 0x1a, 0x28, 0xd6, 0x06, 0xd1, 0x1c, 0x4e, 0xcc, 0x76,
  0x18, 0xde, 0x3f, 0x04, 0x68, 0x87, 0xef, 0x3b, 0xbe, 0x4d, 0x96, 0xe9, 0x0b, 0x42, 0x80, 0xc6,
  0x67, 0x1a, 0x80, 0x2c, 0x30, 0x93, 0x60, 0x72, 0x8b, 0x3e, 0x7b, 0xae, 0x25, 0xf7, 0xc9, 0xb2,
  0x8f, 0xd4, 0x78, 0x87, 0x66, 0xff, 0x20, 0x44, 0xcd, 0x66, 0xf2, 0x48, 0xc9, 0x84, 0x9b, 0x86,
  0x98, 0x14, 0xf3, 0x0d, 0xd9, 0x21, 0x93, 0x3e, 0xac, 0x12, 0x2d, 0x23, 0x99, 0xe1, 0x91, 0xb3,
  0x6b, 0x0c, 0x38, 0x47, 0x77, 0xd3, 0x1a, 0x41, 0xe5, 0x7d, 0x24, 0xc6, 0x68, 0xea, 0xff, 0x8e,
  0xad, 0x21, 0x0e, 0xfa, 0x21, 0xaa, 0xff, 0xb8, 0xc4, 0x5f, 0x33, 0x10, 0xbb, 0x45, 0x92, 0xe4,
  0x3d, 0xea, 0x95, 0x58, 0xe0, 0x15, 0x28, 0xf6, 0x4b, 0xfc, 0xf2, 0x00, 0x65, 0x07, 0x54, 0x4d,
  0xde, 0x21, 0x90, 0xbc, 0x89, 0x50, 0xf8, 0x83, 0x50, 0xb8, 0xd7, 0xba, 0xdd, 0x1f, 0x35, 0x81,
  0x63, 0xf0, 0x88, 0x32, 0x9c, 0x82, 0x47, 0x4f, 0x2b, 0x2b, 0x7c, 0xf0, 0x8f, 0xc2, 0xa0, 0x88,
  0x47, 0x33, 0x24, 0x83, 0x7c, 0x87, 0xea, 0xd8, 0xf3, 0xc6, 0xd0, 0x8f, 0x05, 0x3a, 0xa2, 0xd6,
  0xc7, 0x51, 0x92, 0x3b, 0x43, 0xa1, 0x60, 0xa8, 0x8a, 0xad, 0x28, 0x44, 0x22, 0x9b, 0xe4, 0x1e,
  0x9b, 0x50, 0x1a, 0xf1, 0x0b, 0x84, 0xd0, 0xdd, 0x4f, 0x51, 0x98, 0x7c, 0x40, 0xfc, 0xf2, 0x9d,
  0xdd, 0x6b, 0x65, 0xa2, 0x63, 0x00, 0xf7, 0xc4, 0x67, 0x25, 0xb9, 0x95, 0x89, 0xc4, 0xb7, 0xc8,
  0xdf, 0xe1, 0x02, 0x4a, 0xb5, 0x92, 0x9e, 0xc9, 0x15, 0x8a, 0x7b, 0x24, 0x78, 0x08, 0xcc, 0x84,
  0x0e, 0x48, 0x1c, 0xf0, 0xd9, 0xf1, 0x15, 0x03, 0x05, 0x07, 0x04, 0x62, 0x8d, 0xd0, 0xea, 0x22,
  0xe2, 0x18, 0x1b, 0xf7, 0x23, 0xd6, 0x36, 0x17, 0x6f, 0x11, 0x73, 0xd0, 0x54, 0x4c, 0x07, 0x5b,
  0x24, 0x40, 0x7f, 0x4f, 0x74, 0x01, 0x1a, 0xce, 0x3e, 0xa5, 0x4d, 0x7d, 0x42, 0xed, 0x73, 0xd3,
  0x4d, 0xd4, 0x3e, 0x37, 0xf1, 0x5d, 0x92, 0x25, 0xf6, 0x84, 0xe5, 0xda, 0xfd, 0xe3, 0x50, 0x48,
  0xa8, 0xa2, 0x57, 0xbe, 0x20, 0x46, 0xf4, 0x05, 0xca, 0x29, 0xb8, 0x92, 0xa0, 0xcb, 0x7b, 0xc7,
  0x80, 0x0f, 0x47, 0xf7, 0xf6, 0xa4, 0x0f, 0x6e, 0xba, 0xb9, 0xc9, 0x07, 0x97, 0x4b, 0x1a, 0x1c,
  0xb7, 0xc3, 0x22, 0x04, 0x7f, 0x29, 0x76, 0x3d, 0x5a, 0x29, 0x1c, 0x8b, 0x11, 0x81, 0xb3, 0x1c,
  0x0e, 0xd6, 0x05, 0xe0, 0xec, 0x39, 0xcb, 0x47, 0x97, 0x80, 0x47, 0x96, 0xdd, 0x38, 0x68, 0x1d,
  0xb4, 0xd0, 0xec, 0x79, 0xe5, 0xff, 0x68, 0x2f, 0x93, 0x0f, 0xe5, 0x79, 0xed, 0x4d, 0x1b, 0xda,
  0x7d, 0x2e, 0xc8, 0x33, 0x27, 0x61, 0xcf, 0x75, 0xc6, 0x69, 0xd8, 0x01, 0x28, 0x32, 0xb8, 0x6f,
  0x3c, 0xaa, 0x4f, 0x96, 0x26, 0x62, 0x69, 0x84, 0xcf, 0x28, 0x48, 0x62, 0x89, 0xdd, 0xcb, 0xcc,
  0x4a, 0xc5, 0xcf, 0x30, 0x84, 0x06, 0xbb, 0xfb, 0x41, 0x99, 0x71, 0xa0, 0xb0, 0xab, 0x12, 0x09,
  0xa3, 0x0f, 0x49, 0x84, 0x60, 0x7e, 0x81, 0x44, 0x87, 0xd2, 0xe4, 0x79, 0x9b, 0x0e, 0x68, 0x99,
  0x69, 0x2e, 0x87, 0x7b, 0x52, 0x78, 0x9a, 0x8b, 0xf6, 0x21, 0x73, 0x13, 0x37, 0x0a, 0xe3, 0xb1,
  0xb1, 0x60, 0x98, 0xc4, 0xa2, 0x54, 0xe3, 0x0f, 0xcd, 0x01, 0x34, 0x46, 0x20, 0x7a, 0xa0, 0x46,
  0xe0, 0x70, 0xb3, 0xb1, 0xd2, 0x1c, 0xf3, 0x5e, 0x3d, 0x7f, 0xa8, 0xdb, 0x69, 0xb4, 0xfa, 0xeb,
  0xd1, 0xf2, 0x9c, 0xea, 0xae, 0x6e, 0xc2, 0xff, 0x22, 0xe5, 0xb5, 0xbc, 0x99, 0x0f, 0xca, 0x6b,
  0xb4, 0x11, 0xde, 0xdd, 0xa5, 0xbc, 0x38, 0xd1, 0x4b, 0x3a, 0x68, 0x8d, 0xd9, 0x72, 0x99, 0xd6,
  0x33, 0xd0, 0x89, 0x6c, 0x45, 0x48, 0x7d, 0x1f, 0xd3, 0x19, 0x17, 0x09, 0xf9, 0xb7, 0x98, 0x04,
  0xb7, 0x7b, 0x6d, 0x99, 0x99, 0x34, 0xaf, 0x45, 0x6e, 0x25, 0xee, 0x3e, 0xdb, 0x1d, 0xe2, 0xdb,
  0x37, 0x63, 0xfc, 0xcf, 0x6e, 0x42, 0xf9, 0x6f, 0x90, 0xed, 0x92, 0x0e, 0xc5, 0x41, 0xe7, 0x7b,
  0xd6, 0x3e, 0x99, 0xd5, 0xa0, 0x16, 0xf7, 0x21, 0x23, 0xd1, 0xe3, 0x1d, 0xdc, 0xe1, 0xec, 0x9e,
  0xdc, 0x05, 0x27, 0xf5, 0x0f, 0xe4, 0x3b, 0x47, 0x28, 0xc3, 0xb7, 0xcf, 0xae, 0x4b, 0x27, 0x71,
  0x13, 0xdc, 0x05, 0x2a, 0x59, 0x79, 0xf8, 0x5f, 0xfa, 0x27, 0x45, 0x2b, 0x07, 0xff, 0x07, 0x04,
  0xe1, 0xf1, 0x67, 0x97, 0x91, 0xa1, 0xed, 0x20, 0xfc, 0x72, 0xdc, 0x10, 0x42, 0x06, 0x83, 0xba,
  0xe0, 0x79, 0xe9, 0x98, 0x31, 0xd6, 0xbb, 0xb5, 0xc1, 0x3a, 0xf4, 0x98, 0x3d, 0x63, 0xbb, 0x47,
  0xda, 0x36, 0x3e, 0xae, 0x9c, 0x7f, 0xa5, 0x9e, 0x9a, 0x52, 0xc1, 0x6e, 0xca, 0xc8, 0xd2, 0xa0,
  0xb3, 0x7c, 0x3d, 0xaa, 0x53, 0x08, 0x77, 0x53, 0x95, 0x71, 0xd5, 0x57, 0xdc, 0x4e, 0xb8, 0xaa,
  0x7c, 0x89, 0x65, 0x2a, 0x6a, 0x35, 0xbc, 0x23, 0x9c, 0xc7, 0x9f, 0x7f, 0x80, 0x8e, 0x94, 0xf7,
  0x98, 0x05, 0x2a, 0xec, 0x3e, 0x99, 0xe8, 0x3d, 0x29, 0x1d, 0x7b, 0xfb, 0xa3, 0xd1, 0x9f, 0xf1,
  0x32, 0xb0, 0x49, 0x54, 0xdc, 0x66, 0xcb, 0x89, 0x5c, 0xa1, 0xa7, 0xda, 0xec, 0x3f, 0x5d, 0xff,
  0xf4, 0x57, 0x88, 0x2c, 0x01, 0xe2, 0x3b, 0xc9, 0x59, 0x2c, 0x1f, 0x77, 0x9c, 0x49, 0x30, 0xe8,
  0x0c, 0x4a, 0x77, 0x0f, 0x9e, 0xc8, 0x17, 0xf4, 0x93, 0x7f, 0x62, 0xc6, 0x90, 0x00, 0x1d, 0x7d,
  0xbe, 0x8e, 0xa0, 0xf1, 0x3e, 0x9e, 0xbc, 0x57, 0x20, 0xb2, 0x29, 0x22, 0x22, 0x40, 0xc6, 0xb3,
  0x0a, 0x33, 0x67, 0xc2, 0x96, 0xe0, 0xa7, 0xc6, 0xf3, 0x71, 0x02, 0x0d, 0x93, 0xd0, 0xf9, 0x31,
  0x3e, 0x5c, 0x71, 0xde, 0x2b, 0xf9, 0x28, 0xef, 0x95, 0x2f, 0xc9, 0x1f, 0x69, 0x07, 0x84, 0xc9,
  0x4b, 0xbb, 0x57, 0x61, 0x88, 0x0f, 0x13, 0xfc, 0x57, 0x6a, 0x5d, 0xa0, 0xf7, 0x47, 0xea, 0xad,
  0x90, 0xff, 0x0a, 0x49, 0x1b, 0x87, 0xc4, 0xd7, 0xc9, 0xfc, 0x57, 0xe6, 0x62, 0xee, 0xeb, 0x05,
  0x59, 0xff, 0xf3, 0x72, 0x5f, 0xf1, 0x26, 0xb3, 0x92, 0x3c, 0x99, 0xdc, 0x8f, 0x64, 0x32, 0x2b,
  0xf1, 0x9e, 0x1b, 0x7b, 0xf6, 0x21, 0x4e, 0x74, 0x17, 0xf6, 0x89, 0xfd, 0xb3, 0xf2, 0x60, 0xa4,
  0x13, 0xef, 0xd1, 0x1f, 0xe9, 0x68, 0x11, 0xb9, 0xe4, 0x8e, 0x96, 0x6a, 0x5b, 0x6e, 0xf0, 0x6c,
  0x24, 0xc1, 0xfb, 0xb0, 0xd5, 0x79, 0xd5, 0x72, 0x7d, 0x57, 0x43, 0xd3, 0x34, 0x41, 0xda, 0x85,
  0xee, 0x6a, 0x76, 0xb3, 0xdb, 0x86, 0x05, 0xad, 0xea, 0x73, 0x07, 0xb3, 0xa5, 0xc2, 0xc1, 0x05,
  0xdf, 0xb5, 0xcd, 0x73, 0x6e, 0x93, 0xce, 0xe1, 0x9f, 0x8d, 0xff, 0x61, 0xe9, 0x99, 0xf8, 0x1f,
  0x8e, 0x73, 0x1f, 0x7d, 0x5e, 0xbb, 0x70, 0x95, 0xe4, 0x95, 0xaf, 0xbd, 0x7d, 0xe8, 0x76, 0xf6,
  0xb6, 0x0f, 0xa8, 0xf9, 0x27, 0xec, 0x43, 0x7e, 0x2e, 0x6b, 0xe6, 0xff, 0x3c, 0xf7, 0xe1, 0xcf,
  0xd0, 0xa1, 0x90, 0x68, 0x58, 0xac, 0x43, 0xe1, 0x21, 0xf1, 0xf5, 0xcf, 0xc4, 0xa1, 0xd0, 0x9b,
  0xcd, 0x4a, 0xf2, 0x6c, 0xfe, 0x1c, 0x1c, 0x0a, 0x69, 0x2e, 0xcf, 0xd0, 0xa1, 0x70, 0x9c, 0x73,
  0x1e, 0xad, 0x4e, 0x92, 0x0b, 0x60, 0x84, 0x7e, 0x3a, 0x99, 0xf4, 0x87, 0xd7, 0xbd, 0x43, 0xa2,
  0xdf, 0x93, 0x48, 0x5d, 0xc2, 0x4b, 0xd0, 0x6b, 0x95, 0x8d, 0xf9, 0x49, 0xcf, 0x98, 0x3f, 0xf9,
  0x56, 0xb9, 0x9f, 0x23, 0xb4, 0xb2, 0xfb, 0xbe, 0x30, 0xa7, 0xa2, 0x9d, 0x3a, 0xa6, 0xe0, 0x90,
  0xf5, 0xa5, 0x14, 0x99, 0x7a, 0xef, 0xed, 0x5e, 0xcc, 0x02, 0x55, 0x31, 0x3c, 0x6b, 0xa5, 0x22,
  0x65, 0xe2, 0xc8, 0x3b, 0xb6, 0xfb, 0x6a, 0xcb, 0x71, 0x13, 0xef, 0xc3, 0xc5, 0xac, 0x53, 0x02,
  0x1f, 0x4e, 0xdc, 0xdf, 0x9a, 0xd5, 0x39, 0x66, 0xbb, 0x11, 0x8e, 0x97, 0x72, 0x4b, 0x7f, 0xba,
  0x7e, 0xf5, 0x9f, 0xb8, 0x82, 0x83, 0x6a, 0x9c, 0x7f, 0xda, 0x23, 0xad, 0x48, 0x08, 0x5e, 0xfd,
  0x4b, 0xb5, 0x56, 0x47, 0x99, 0x55, 0xd4, 0x11, 0x8f, 0xdc, 0xdb, 0x04, 0xb7, 0xcc, 0x44, 0x5c,
  0x8f, 0xe8, 0xcb, 0x05, 0x18, 0x00, 0x47, 0xe7, 0x0b, 0xba, 0xb9, 0xea, 0xb4, 0xea, 0x01, 0x46,
  0x42, 0x5e, 0xa4, 0x77, 0xb8, 0x20, 0xee, 0xcf, 0x40, 0x8f, 0xe1, 0x93, 0x4a, 0xdb, 0x3d, 0x18,
  0xc0, 0x66, 0x57, 0x58, 0xd1, 0xa0, 0xfd, 0x37, 0xe0, 0x45, 0xb0, 0xfd, 0xeb, 0x64, 0xae, 0x44,
  0x93, 0xc9, 0x07, 0xd1, 0x8d, 0x4e, 0x8a, 0x7e, 0x40, 0x70, 0x60, 0x77, 0x52, 0xf6, 0x06, 0xf0,
  0x03, 0xd4, 0xaa, 0xbf, 0xf8, 0xb5, 0x46, 0x5c, 0xf6, 0x9b, 0xbd, 0x60, 0x19, 0x40, 0x55, 0x9c,
  0x7e, 0x35, 0x21, 0x3e, 0xa0, 0x0f, 0xcc, 0x0d, 0x76, 0xa4, 0x81, 0xda, 0x7c, 0xe0, 0xc2, 0xa0,
  0x67, 0x03, 0x56, 0x8d, 0x51, 0xe8, 0x8e, 0x1b, 0xa5, 0x47, 0x4d, 0x74, 0x91, 0x92, 0x5f, 0x21,
  0xdd, 0xdb, 0x75, 0xca, 0x27, 0xa3, 0x1b, 0xf3, 0x24, 0xbb, 0x28, 0xf7, 0xea, 0x23, 0x26, 0x29,
  0x1f, 0x5d, 0xa3, 0x01, 0xfa, 0x16, 0x3b, 0x64, 0x61, 0xfb, 0x40, 0x47, 0x4a, 0x0f, 0x19, 0x21,
  0xfc, 0x96, 0x68, 0xc5, 0x9c, 0xc6, 0x4e, 0x6b, 0x34, 0x12, 0x85, 0x68, 0x61, 0xee, 0xf2, 0xd3,
  0x76, 0xee, 0xd1, 0x21, 0xee, 0xf7, 0x5d, 0x93, 0x4e, 0x5d, 0xbe, 0x61, 0xa1, 0x06, 0xb8, 0x22,
  0x88, 0x27, 0x4a, 0xf0, 0x23, 0x97, 0xd7, 0xfc, 0x5b, 0xc1, 0xd9, 0x38, 0x0d, 0xd9, 0xa9, 0xf5,
  0x5b, 0x3d, 0x77, 0x69, 0xdf, 0x66, 0xab, 0x53, 0xef, 0x6e, 0x66, 0x01, 0xb5, 0xfa, 0xfd, 0x6e,
  0xbf, 0xda, 0x18, 0x74, 0x6a, 0x18, 0x4e, 0x22, 0xb5, 0xee, 0x9c, 0x49, 0x3b, 0xfd, 0x5a, 0x1a,
  0x95, 0xfa, 0x34, 0xac, 0x45, 0x1a, 0xbe, 0x1b, 0x18, 0xdc, 0x02, 0x18, 0x93, 0x9d, 0xa5, 0xc2,
  0xa9, 0xa9, 0xbf, 0x5a, 0xd5, 0x8e, 0xbc, 0xf9, 0xe6, 0xeb, 0x6f, 0x96, 0xa7, 0xd2, 0x58, 0x7e,
  0x0a, 0x0b, 0xc3, 0x33, 0xd5, 0xc1, 0xf2, 0x95, 0x3e, 0x00, 0x48, 0xbf, 0xa3, 0x35, 0xac, 0xb6,
  0x63, 0x57, 0x86, 0x95, 0x7d, 0xfb, 0x44, 0xfb, 0x9a, 0x08, 0x0f, 0xe0, 0x1a, 0x5b, 0x30, 0x38,
  0xcf, 0x4e, 0xf1, 0xbf, 0x07, 0x36, 0x68, 0xf7, 0xa4, 0xf6, 0x74, 0xfb, 0x2f, 0xb5, 0xdb, 0x29,
  0x1d, 0xc3, 0xa4, 0xe9, 0x46, 0x16, 0x76, 0xf8, 0x88, 0x55, 0x6b, 0xa6, 0x52, 0x76, 0xba, 0x65,
  0x54, 0x97, 0xec, 0x2c, 0x81, 0x20, 0xd2, 0x09, 0x1e, 0xbd, 0x22, 0xa5, 0xf3, 0x70, 0x01, 0xe9,
  0x93, 0x2c, 0x94, 0x40, 0x5a, 0xdc, 0x6a, 0x4f, 0xfb, 0x37, 0x8c, 0xd3, 0xfc, 0x7a, 0x68, 0x9a,
  0x59, 0x06, 0x4e, 0x9d, 0x6c, 0x9d, 0xaa, 0x56, 0xab, 0xae, 0x61, 0x54, 0xc6, 0x0c, 0x82, 0x6c,
  0x07, 0xfe, 0x28, 0x6c, 0x75, 0x04, 0x00, 0x2f, 0xdd, 0x0d, 0x7f, 0x04, 0x81, 0xe6, 0x02, 0xb6,
  0x17, 0xd7, 0x90, 0x6a, 0x02, 0xc2, 0xfa, 0xd5, 0xb0, 0x56, 0xab, 0x91, 0x72, 0x61, 0x48, 0x5e,
  0x48, 0x08, 0xad, 0xdd, 0xb5, 0xea, 0x87, 0xe8, 0x47, 0x4a, 0x29, 0xc0, 0xc2, 0x2a, 0xd0, 0xe7,
  0x13, 0xf0, 0x88, 0x6b, 0xa9, 0x7c, 0xf7, 0x43, 0x41, 0x50, 0x99, 0x97, 0xf9, 0xcf, 0x50, 0x39,
  0x1e, 0xe7, 0x21, 0xd0, 0x90, 0x36, 0x3b, 0x4b, 0xa0, 0xc8, 0x40, 0x54, 0x18, 0xa6, 0x3d, 0x7c,
  0x12, 0x0a, 0x3a, 0x02, 0x3e, 0xdd, 0x05, 0xc3, 0x93, 0x2e, 0xcf, 0x4d, 0x72, 0xdf, 0x70, 0x1f,
  0x54, 0x1f, 0x7d, 0x42, 0x10, 0x7b, 0x9b, 0xfc, 0xfd, 0xd9, 0x29, 0x26, 0x9e, 0xd7, 0x78, 0x9e,
  0x33, 0xbb, 0x97, 0xca, 0x21, 0x53, 0x32, 0xb5, 0x99, 0x2b, 0xd2, 0x89, 0x24, 0x94, 0x42, 0xbb,
  0x06, 0x99, 0x3b, 0xb0, 0xfb, 0x6f, 0xc4, 0x11, 0x2f, 0x3b, 0x67, 0xa4, 0x02, 0x0f, 0xd8, 0x29,
  0xa7, 0xd7, 0x22, 0xf6, 0xdb, 0xec, 0x0e, 0xfa, 0x6d, 0x10, 0x13, 0x40, 0x2f, 0x70, 0xfb, 0x03,
  0x5b, 0x7b, 0xfc, 0xee, 0xc7, 0x2a, 0xa6, 0xed, 0x5e, 0xe6, 0xa7, 0xc9, 0xbc, 0xd9, 0x54, 0xe8,
  0x22, 0x3d, 0x3b, 0x26, 0x26, 0x43, 0x38, 0x9e, 0x3c, 0xc3, 0x80, 0xd8, 0xa9, 0x14, 0x15, 0xbc,
  0xa7, 0x55, 0xb5, 0x79, 0x93, 0x5a, 0x31, 0x02, 0xfd, 0x11, 0x9c, 0x07, 0x3b, 0x3c, 0x38, 0xcf,
  0x7a, 0x4c, 0x31, 0x5f, 0xaa, 0xf1, 0xcd, 0x3f, 0xfe, 0xe5, 0xfb, 0x5a, 0x5e, 0x10, 0x04, 0xc3,
  0x47, 0x99, 0x75, 0xeb, 0x2c, 0x39, 0x45, 0x91, 0x10, 0xe7, 0xa4, 0x6a, 0x20, 0x0e, 0xba, 0x69,
  0xd4, 0x7f, 0x5e, 0x6b, 0x75, 0x08, 0x8b, 0x10, 0x3b, 0x5d, 0xad, 0xd3, 0xdd, 0xac, 0x02, 0x9f,
  0xd1, 0x0e, 0x5b, 0xae, 0x0d, 0x3b, 0xc9, 0x5e, 0x92, 0x56, 0xe5, 0x54, 0x4f, 0x9e, 0xc2, 0xad,
  0x07, 0xd0, 0x48, 0xb5, 0x6d, 0x57, 0x6b, 0x55, 0xa9, 0x8d, 0x4c, 0xae, 0xd2, 0x5a, 0xaa, 0x9a,
  0x95, 0x56, 0x26, 0x43, 0xcd, 0x88, 0x86, 0xea, 0x7e, 0x33, 0xd0, 0x26, 0x82, 0x31, 0xf6, 0x9e,
  0x32, 0x32, 0xad, 0x17, 0x79, 0xaf, 0x2f, 0xce, 0x9b, 0x2f, 0x82, 0x16, 0x65, 0x12, 0x40, 0x69,
  0xbc, 0x93, 0x6c, 0x6f, 0xe0, 0x34, 0x53, 0x75, 0x2c, 0x7f, 0x14, 0x96, 0x06, 0xc0, 0x16, 0x30,
  0x74, 0xd5, 0xed, 0x83, 0x24, 0x0c, 0x8f, 0x20, 0x13, 0xaf, 0x62, 0xa0, 0x8e, 0x54, 0x3e, 0xad,
  0x9b, 0xba, 0x31, 0xa3, 0x97, 0xf5, 0x19, 0x2a, 0x0b, 0xcd, 0x0d, 0x5c, 0x3b, 0xb9, 0x34, 0xf5,
  0x83, 0x11, 0x6b, 0x38, 0x5d, 0x61, 0x1d, 0x56, 0x00, 0xde, 0xbc, 0x45, 0x6a, 0x5a, 0x0e, 0x8c,
  0xd8, 0x4a, 0x59, 0x48, 0xae, 0x78, 0x31, 0x78, 0x9e, 0x9e, 0x86, 0x3f, 0x59, 0xa7, 0x0b, 0xe3,
  0xdf, 0xa8, 0x2e, 0x6d, 0xec, 0xaf, 0x56, 0x61, 0xd0, 0x43, 0x89, 0x1e, 0xad, 0x0d, 0x5a, 0xed,
  0xfa, 0xea, 0xc6, 0x19, 0x42, 0xb5, 0x14, 0xc6, 0x02, 0xb0, 0x80, 0x8a, 0xf5, 0x5f, 0xa9, 0xa7,
  0x35, 0xa4, 0x26, 0x69, 0x8d, 0xf8, 0x41, 0x5a, 0x6b, 0xb4, 0xda, 0xed, 0x43, 0xec, 0x91, 0xf5,
  0x9e, 0xd6, 0x30, 0xac, 0x5f, 0x1a, 0x6f, 0x23, 0xbe, 0x89, 0x07, 0x5e, 0xd2, 0x4e, 0x78, 0xad,
  0x54, 0xe3, 0x68, 0x81, 0xd4, 0x8f, 0x40, 0xca, 0xfd, 0xde, 0x3b, 0x83, 0x0d, 0xbf, 0xc2, 0xda,
  0x63, 0xef, 0xb2, 0xad, 0x0e, 0xfc, 0x3d, 0x7a, 0xfc, 0xb5, 0x57, 0xab, 0xba, 0x2e, 0x6a, 0x88,
  0x39, 0xe3, 0x40, 0x0d, 0x7f, 0x0b, 0xc3, 0x35, 0x24, 0x86, 0x37, 0xa5, 0xf2, 0xb7, 0x70, 0x0c,
  0x40, 0xa1, 0xbc, 0x14, 0xa2, 0x0e, 0xbf, 0xa7, 0x96, 0x1e, 0x5f, 0xf9, 0x5a, 0x89, 0x53, 0xa3,
  0xd1, 0x89, 0x2d, 0x1e, 0xfc, 0xc0, 0xbb, 0xfb, 0x32, 0xf7, 0xf3, 0x78, 0xae, 0xce, 0xa0, 0xc4,
  0x9f, 0x15, 0xee, 0x24, 0xc2, 0xe1, 0x89, 0xaa, 0x3f, 0xda, 0x6e, 0xa3, 0x01, 0x14, 0xe9, 0x04,
  0x2a, 0xe8, 0xdb, 0xdb, 0xfe, 0x6b, 0x16, 0x58, 0x93, 0x2f, 0xdd, 0xf4, 0x74, 0xcc, 0x07, 0xb5,
  0x76, 0x61, 0xce, 0xe4, 0x2b, 0x74, 0x62, 0x11, 0x5d, 0x34, 0x4e, 0x54, 0xf9, 0x1b, 0xb6, 0x3b,
  0x47, 0xab, 0xb9, 0x92, 0xf4, 0x13, 0xe6, 0xfb, 0x6a, 0x75, 0x6e, 0x3e, 0x0d, 0xff, 0xbe, 0x59,
  0xcd, 0x99, 0xf8, 0xef, 0xf1, 0x6a, 0x2e, 0x8f, 0xff, 0xae, 0x54, 0x0b, 0x52, 0xc1, 0xda, 0x89,
  0xea, 0x89, 0x0c, 0x96, 0xc6, 0x3f, 0x6f, 0x02, 0x60, 0x1c, 0xad, 0x1e, 0xc5, 0xc7, 0xe3, 0xf8,
  0x67, 0xc5, 0x2f, 0xd7, 0xa9, 0xe2, 0x7e, 0x64, 0xdb, 0x76, 0xe7, 0x8c, 0xdb, 0xac, 0xf0, 0xa9,
  0x02, 0x94, 0xfc, 0x4d, 0xf5, 0x35, 0xcb, 0x6d, 0x66, 0xe1, 0x29, 0x05, 0x4b, 0x43, 0x7b, 0x96,
  0xc6, 0x3b, 0xac, 0xe2, 0xbd, 0x75, 0xce, 0x7b, 0xcf, 0x87, 0x2f, 0x40, 0x6b, 0x7a, 0x3a, 0x85,
  0xe5, 0x32, 0xd8, 0x88, 0xb1, 0xe8, 0x03, 0x1c, 0xeb, 0x6f, 0x1d, 0x04, 0x21, 0x2c, 0xfa, 0x37,
  0x33, 0x58, 0xc8, 0x98, 0xcd, 0x57, 0xa8, 0x33, 0x78, 0x9d, 0x11, 0x45, 0xf1, 0x1d, 0x76, 0x04,
  0xef, 0x66, 0xa4, 0x77, 0x43, 0x6f, 0xcc, 0x7d, 0x3a, 0xb2, 0xa5, 0x32, 0xd5, 0x2a, 0x56, 0x5f,
  0xce, 0x95, 0xbd, 0x2e, 0xfd, 0xa9, 0x9d, 0x23, 0x6a, 0x57, 0x3b, 0x31, 0x9b, 0xea, 0x64, 0x72,
  0x34, 0x4a, 0x0f, 0x8f, 0x7a, 0xe7, 0x52, 0x2d, 0x0f, 0xf1, 0x70, 0x95, 0x66, 0x5a, 0x2f, 0x52,
  0x71, 0xea, 0xc5, 0x2f, 0x76, 0x3e, 0xb5, 0x21, 0x17, 0x3b, 0x3e, 0x53, 0x3b, 0x9a, 0x49, 0x6d,
  0xb0, 0xa9, 0xcd, 0xd2, 0x30, 0x5e, 0xac, 0x1d, 0xa5, 0x3a, 0x40, 0x62, 0x7b, 0xdd, 0xf6, 0x79,
  0x14, 0x2a, 0x34, 0xd2, 0x9c, 0x1d, 0xbe, 0x96, 0x3d, 0xd7, 0x61, 0x4b, 0xbc, 0x6e, 0xf5, 0x52,
  0xa9, 0x0d, 0x92, 0x0b, 0xa8, 0x7b, 0xa0, 0x20, 0x2f, 0xb7, 0xce, 0xd9, 0x75, 0xd0, 0xce, 0x67,
  0x80, 0xd5, 0xcf, 0x50, 0x67, 0xd2, 0x4b, 0x23, 0xfb, 0xf7, 0xd0, 0x4e, 0x4a, 0xd7, 0x18, 0xcb,
  0x85, 0x0e, 0x10, 0xab, 0xa9, 0x97, 0x33, 0xdd, 0x4e, 0x19, 0x38, 0xf7, 0x66, 0x47, 0x73, 0x9b,
  0xb6, 0xd6, 0xc7, 0x33, 0x5c, 0x0d, 0x14, 0x02, 0x3b, 0xad, 0x59, 0xed, 0x6e, 0xe7, 0x8c, 0xc6,
  0xf4, 0x8e, 0xb4, 0x86, 0x0a, 0xb9, 0x36, 0xe8, 0x69, 0xe8, 0x1f, 0xc2, 0x87, 0x83, 0x6d, 0xbc,
  0x01, 0x43, 0x3a, 0x7d, 0x60, 0x0b, 0x46, 0x61, 0xca, 0x1d, 0x0e, 0xd3, 0x07, 0xb6, 0x52, 0x7c,
  0x96, 0xca, 0x7b, 0xed, 0xf4, 0x0c, 0xcc, 0x62, 0xe6, 0xb4, 0x46, 0x75, 0x70, 0x31, 0x27, 0xa9,
  0x75, 0x9a, 0x8f, 0xfa, 0x67, 0x9a, 0x75, 0xae, 0xe5, 0x68, 0x2e, 0x88, 0xfe, 0x8e, 0x96, 0x9a,
  0xd3, 0x70, 0x89, 0x1c, 0x83, 0x0f, 0xe7, 0xfc, 0xab, 0xf8, 0x0b, 0xa8, 0x44, 0x1a, 0x1e, 0x19,
  0xf5, 0x67, 0x14, 0x83, 0x6d, 0xe1, 0xf9, 0xe3, 0x58, 0xab, 0x3a, 0x27, 0xf3, 0x03, 0x17, 0x98,
  0x80, 0xbb, 0x58, 0x65, 0x9f, 0x2a, 0xee, 0xcc, 0x8c, 0xc2, 0x0e, 0x36, 0x08, 0x20, 0x66, 0x24,
  0x10, 0x7c, 0xd1, 0x9d, 0xe5, 0x65, 0xa5, 0x62, 0xe7, 0xab, 0xc1, 0xe5, 0x66, 0x5f, 0xd9, 0x78,
  0x66, 0xaa, 0xa7, 0x17, 0x69, 0x27, 0xcf, 0xe5, 0xaa, 0xfa, 0x01, 0x8c, 0xbd, 0xfb, 0xea, 0x50,
  0xd7, 0xce, 0xd3, 0x8f, 0xf3, 0xf0, 0x74, 0x2e, 0x8f, 0x4f, 0x84, 0x5f, 0x6f, 0xe2, 0x87, 0xbc,
  0xf8, 0xe0, 0xb8, 0xfd, 0xee, 0x59, 0xf4, 0x3a, 0x38, 0xb3, 0x66, 0xa5, 0x0a, 0x66, 0xba, 0x58,
  0x4a, 0x1f, 0x2c, 0xa6, 0xcd, 0xec, 0xbc, 0x21, 0xbe, 0xb1, 0xf0, 0xce, 0xe8, 0x7c, 0x30, 0xbb,
  0x74, 0x5a, 0xf4, 0x49, 0x13, 0xc7, 0x4e, 0x91, 0xc0, 0x69, 0xe7, 0x44, 0x9f, 0x99, 0x39, 0x6c,
  0x5c, 0xb4, 0xcd, 0x88, 0x5f, 0xa7, 0xd6, 0x04, 0x01, 0x58, 0xc7, 0x08, 0x16, 0x00, 0x01, 0x30,
  0x41, 0x0b, 0x43, 0x2f, 0x59, 0x8e, 0x8d, 0xe3, 0x05, 0x35, 0xb7, 0x55, 0xaf, 0xb7, 0x6d, 0x9d,
  0xb6, 0xb9, 0xaa, 0xf3, 0x10, 0xa7, 0xf0, 0x53, 0x50, 0x46, 0xe8, 0xd8, 0xd4, 0x97, 0x0e, 0x6c,
  0x09, 0xbc, 0x5a, 0xde, 0x90, 0x96, 0xa0, 0x4c, 0xa8, 0x4d, 0x06, 0x1c, 0x58, 0x9b, 0xe1, 0xe2,
  0x2c, 0x76, 0xc9, 0x46, 0xc9, 0x41, 0xfc, 0x6f, 0xd9, 0x5e, 0x32, 0x9e, 0x42, 0xa7, 0xed, 0x28,
  0x21, 0x83, 0x66, 0xd7, 0x3e, 0xaf, 0xfd, 0x43, 0x51, 0x43, 0x8d, 0x0e, 0x9e, 0xe8, 0x72, 0x72,
  0x9d, 0xef, 0xf0, 0xb9, 0x88, 0x6d, 0x3d, 0xb7, 0x0a, 0xb5, 0xaa, 0x27, 0xcd, 0x74, 0x21, 0xbd,
  0x90, 0xce, 0xe5, 0xd2, 0xb9, 0x39, 0xe2, 0xf8, 0xf4, 0xda, 0x93, 0x5e, 0x5b, 0xd5, 0x25, 0xb6,
  0xb1, 0x40, 0x5b, 0x5a, 0x8b, 0x1d, 0x43, 0xb4, 0x14, 0x58, 0xa7, 0x00, 0x2a, 0x89, 0x15, 0x3b,
  0x9a, 0x99, 0x0f, 0xae, 0xd9, 0xa4, 0x6b, 0xc3, 0x66, 0x07, 0x42, 0xb7, 0xba, 0x02, 0x02, 0x0b,
  0xdd, 0x6e, 0xb7, 0xed, 0xb6, 0x7a, 0x1a, 0x85, 0x94, 0x04, 0x3e, 0x51, 0x73, 0x1d, 0x6d, 0x06,
  0xf6, 0xc2, 0xc3, 0x78, 0x7c, 0x24, 0x88, 0x6e, 0xb6, 0xdc, 0x37, 0xf1, 0x33, 0x9f, 0x3b, 0x51,
  0x01, 0x4f, 0x43, 0x60, 0x94, 0x40, 0x06, 0xdd, 0xda, 0xb9, 0x6a, 0x70, 0x36, 0x40, 0xb7, 0xe3,
  0x20, 0x15, 0x7b, 0xc1, 0xa5, 0xa8, 0xb5, 0xfa, 0xb5, 0xb6, 0x8d, 0x95, 0x61, 0xd6, 0xb5, 0x73,
  0x30, 0xe9, 0x1a, 0x2d, 0x40, 0x0d, 0x61, 0xa6, 0x4f, 0x17, 0xc0, 0xd8, 0x84, 0x0f, 0xb0, 0x98,
  0x92, 0x12, 0x94, 0x72, 0x23, 0x5d, 0x08, 0x34, 0xb3, 0x45, 0x1f, 0x38, 0x39, 0xc5, 0x3d, 0x57,
  0x4d, 0xd1, 0xd8, 0x32, 0x44, 0x25, 0x67, 0xf3, 0xe1, 0xf1, 0x88, 0xc9, 0xe2, 0x98, 0x70, 0x51,
  0xd8, 0xf6, 0xf4, 0xcf, 0x89, 0x0d, 0x41, 0x12, 0x01, 0xcf, 0xbc, 0x8f, 0x03, 0x5b, 0xd4, 0x90,
  0xba, 0x71, 0xcc, 0x1b, 0x85, 0x46, 0x7a, 0x74, 0x28, 0x86, 0x2d, 0x45, 0xac, 0xd6, 0x35, 0x6e,
  0xbb, 0xe8, 0x76, 0xd6, 0xbb, 0x03, 0xc7, 0x26, 0x11, 0x00, 0x74, 0x03, 0x54, 0xd2, 0x5a, 0xbd,
  0x94, 0xbd, 0xe1, 0x02, 0x2d, 0xfa, 0xab, 0xd5, 0xd7, 0x8f, 0x65, 0x1d, 0x12, 0xcd, 0x5a, 0x8d,
  0xf3, 0x29, 0x6f, 0x33, 0x89, 0x50, 0x6d, 0x0c, 0xd3, 0x53, 0x07, 0xb6, 0x50, 0x14, 0x1a, 0x4e,
  0x19, 0xba, 0x68, 0xa7, 0x6d, 0x5b, 0x1b, 0x36, 0x86, 0x2f, 0xa8, 0xdb, 0xd8, 0x8e, 0x21, 0x66,
  0xcf, 0xb6, 0x3c, 0x4a, 0x46, 0x39, 0xbd, 0xe8, 0x6c, 0x9c, 0x11, 0x73, 0x41, 0x0b, 0xbd, 0xae,
  0x61, 0x58, 0xf7, 0x95, 0x2e, 0x4c, 0xda, 0xd4, 0x4c, 0x20, 0x94, 0x27, 0x86, 0xf0, 0xe7, 0xe8,
  0x30, 0x64, 0x1e, 0x62, 0xe7, 0x0c, 0xc1, 0x78, 0xb8, 0xdc, 0x2e, 0x01, 0x88, 0x4e, 0xf4, 0x67,
  0xc8, 0x14, 0x7f, 0x4e, 0xea, 0x39, 0x3f, 0xc1, 0x75, 0xe1, 0xd4, 0x7b, 0xe8, 0xef, 0xa9, 0x27,
  0xe9, 0x0d, 0x61, 0xd4, 0x7e, 0x35, 0x89, 0x0f, 0xd1, 0xe2, 0x4b, 0x75, 0xd0, 0x40, 0xe5, 0xc3,
  0x40, 0x10, 0x2a, 0x04, 0x10, 0xe4, 0xb3, 0x45, 0xef, 0x15, 0x36, 0x86, 0xbc, 0x08, 0xe8, 0x1a,
  0xd2, 0x06, 0xe5, 0x7d, 0xcd, 0xea, 0x89, 0xd7, 0xb3, 0x62, 0x12, 0x08, 0x9a, 0x43, 0x6f, 0x42,
  0xb4, 0x01, 0xe2, 0xe7, 0x39, 0xf5, 0xa7, 0x00, 0x9a, 0x21, 0xa9, 0xfe, 0xb0, 0xa6, 0xb8, 0xf0,
  0x20, 0xf0, 0x02, 0x9a, 0x1d, 0x67, 0x68, 0xb6, 0x2f, 0xe5, 0x29, 0xfb, 0x92, 0xcc, 0x0a, 0x1f,
  0x7c, 0x69, 0xb5, 0xd6, 0xb7, 0x41, 0xfa, 0xe7, 0xc2, 0x55, 0x0a, 0x56, 0x7a, 0x83, 0x71, 0x4c,
  0x28, 0x94, 0x25, 0x53, 0xdd, 0xc6, 0x19, 0xd8, 0x56, 0x5d, 0xbc, 0x62, 0x8e, 0x02, 0x35, 0xc7,
  0x39, 0x0e, 0xb8, 0x5d, 0xd5, 0xbd, 0xf0, 0x97, 0x0d, 0x04, 0xc4, 0xca, 0x84, 0x81, 0x88, 0x23,
  0x4e, 0x5a, 0x4a, 0xc1, 0x60, 0xba, 0xf9, 0xa4, 0x93, 0x16, 0x76, 0x90, 0xc1, 0x6d, 0xec, 0x19,
  0x32, 0x85, 0x39, 0xcc, 0x76, 0xa8, 0x18, 0x12, 0xdf, 0xce, 0xb4, 0x3a, 0x75, 0xfb, 0x5c, 0xf9,
  0xe0, 0xc1, 0x83, 0xba, 0xa2, 0xae, 0x63, 0xac, 0xca, 0xac, 0xd5, 0xeb, 0x01, 0x23, 0x38, 0xd4,
  0x04, 0xa5, 0x20, 0x05, 0x53, 0x83, 0x59, 0x0f, 0x0d, 0xd4, 0x9b, 0x55, 0xfb, 0x05, 0x47, 0x8d,
  0xf6, 0x5a, 0x3b, 0xbd, 0x61, 0xb5, 0xd3, 0x08, 0xfd, 0xf2, 0x52, 0xc6, 0x8a, 0xfd, 0x62, 0xe1,
  0xd8, 0x62, 0x66, 0x91, 0x14, 0x1e, 0xe2, 0x19, 0x0b, 0xa0, 0x2d, 0xd0, 0x89, 0x34, 0x7d, 0x06,
  0x1a, 0x9c, 0x01, 0x09, 0x65, 0x06, 0x1b, 0x65, 0xc5, 0x54, 0x3f, 0x0c, 0x9d, 0xe0, 0x5d, 0x97,
  0x3f, 0xa1, 0x30, 0x52, 0xc5, 0x11, 0x65, 0x6b, 0x6d, 0xf4, 0xc0, 0xf8, 0xdb, 0x99, 0x5c, 0x1e,
  0x24, 0xa0, 0xde, 0x39, 0xa5, 0x94, 0xdb, 0xed, 0xc9, 0x85, 0x7e, 0x96, 0x29, 0x98, 0xa2, 0x90,
  0xac, 0x47, 0x09, 0x94, 0xdd, 0x1a, 0x3b, 0x89, 0xe0, 0xc0, 0x08, 0x0d, 0xc2, 0xca, 0xd5, 0x4a,
  0xcb, 0xb5, 0x63, 0xb5, 0x2b, 0xa1, 0x4b, 0x01, 0xc0, 0xd5, 0xcf, 0xff, 0xc0, 0x2a, 0x14, 0xda,
  0x2a, 0xc4, 0x8d, 0xc6, 0x5b, 0x74, 0x13, 0xea, 0x8a, 0xb0, 0x6e, 0x60, 0x1c, 0x13, 0xbc, 0x6e,
  0x75, 0x19, 0xad, 0x0d, 0x1a, 0x59, 0x08, 0xc8, 0xd3, 0x99, 0x39, 0x76, 0x5d, 0x12, 0xbe, 0xae,
  0xf8, 0x2a, 0x10, 0x85, 0x8b, 0x8f, 0x84, 0xe6, 0xa3, 0x4d, 0x4f, 0x6b, 0xa9, 0xfd, 0x38, 0xd1,
  0xed, 0x6d, 0xfa, 0xc7, 0x57, 0x44, 0x97, 0x4c, 0xe3, 0x2f, 0x1a, 0xdb, 0x1e, 0x34, 0xb6, 0x3c,
  0x29, 0x66, 0xaf, 0x56, 0x4b, 0x4c, 0x4f, 0x2b, 0x71, 0x35, 0xcd, 0x64, 0x6a, 0x5a, 0x7e, 0x2e,
  0x56, 0x4d, 0x9b, 0x58, 0x4b, 0x63, 0xaf, 0xd7, 0xac, 0xfe, 0x09, 0x5f, 0x1f, 0xcb, 0xa7, 0x41,
  0xd7, 0xe9, 0x64, 0xf2, 0x46, 0x84, 0x0a, 0xd4, 0xf1, 0xdf, 0x51, 0x38, 0x50, 0x62, 0x19, 0x4e,
  0xf5, 0xa4, 0xce, 0x43, 0x4f, 0x83, 0x02, 0x22, 0x6e, 0x88, 0xc0, 0x13, 0x8b, 0x3a, 0x8d, 0x4f,
  0xd6, 0xda, 0xdc, 0xc2, 0x5a, 0x4d, 0x3f, 0x15, 0xa8, 0xce, 0x65, 0xba, 0x93, 0xfa, 0x8a, 0x85,
  0x15, 0x8a, 0xc0, 0x00, 0xd3, 0xfa, 0x4f, 0xf1, 0xf1, 0xa7, 0x7d, 0x97, 0x95, 0xc6, 0x0d, 0x80,
  0xf1, 0x91, 0x24, 0x74, 0xee, 0xd5, 0xb5, 0xf6, 0xa4, 0x52, 0x50, 0xb3, 0xba, 0x31, 0x5b, 0x40,
  0xad, 0x4a, 0x7a, 0x07, 0x82, 0x91, 0xa4, 0xa3, 0xcd, 0x70, 0x19, 0x24, 0x83, 0xd3, 0x07, 0xc5,
  0x50, 0x15, 0xeb, 0xb9, 0x96, 0xd6, 0x94, 0x5f, 0x03, 0x4c, 0x56, 0xa5, 0x69, 0x9f, 0xf4, 0x54,
  0xdb, 0x8d, 0x74, 0xc1, 0x38, 0xb5, 0xbd, 0xad, 0x0b, 0x9f, 0x37, 0x56, 0x09, 0x87, 0xad, 0x8a,
  0x31, 0xe7, 0x22, 0x24, 0xcc, 0xf3, 0xea, 0x3b, 0x4f, 0xb0, 0xc1, 0x51, 0xc5, 0xc9, 0x35, 0xde,
  0x5e, 0x35, 0xd3, 0xf9, 0x80, 0xd4, 0x2a, 0x09, 0x69, 0x28, 0xb8, 0x9d, 0xc3, 0x2b, 0xab, 0x9e,
  0x14, 0x06, 0xb0, 0x86, 0x48, 0xe8, 0x8d, 0xcc, 0x97, 0x7f, 0x53, 0xe7, 0x66, 0xd8, 0x32, 0x44,
  0x09, 0xc1, 0xa9, 0xf3, 0x99, 0x42, 0xe0, 0x7d, 0x82, 0x44, 0x2c, 0xfa, 0x96, 0x04, 0xe2, 0x12,
  0xca, 0xc3, 0xd2, 0x8e, 0x07, 0x56, 0x2e, 0x5a, 0x40, 0xfe, 0x5b, 0xd9, 0x8a, 0x4a, 0x1e, 0xb9,
  0xbe, 0x99, 0xb1, 0x20, 0x8c, 0xa6, 0xf0, 0x2d, 0x4a, 0x1d, 0x98, 0x4f, 0x1f, 0x4c, 0xe7, 0xf2,
  0x13, 0x2b, 0x04, 0x6b, 0x41, 0x75, 0x20, 0x15, 0x05, 0x28, 0xcf, 0x4c, 0x3f, 0x38, 0x38, 0x4e,
  0x3d, 0x78, 0x0e, 0xb2, 0xa2, 0x38, 0xb2, 0x8a, 0xd3, 0x47, 0x39, 0xc0, 0xc7, 0x69, 0xa5, 0xfe,
  0x67, 0x4f, 0xea, 0xe7, 0xb0, 0x1e, 0xa1, 0x90, 0x72, 0xa9, 0x0c, 0xa1, 0x6c, 0x88, 0xb2, 0xda,
  0x5a, 0x3b, 0x28, 0x99, 0x79, 0xcc, 0x52, 0x36, 0xf8, 0xe3, 0xae, 0x34, 0x6c, 0x17, 0xb6, 0x48,
  0x9f, 0x65, 0x51, 0xa6, 0xb3, 0x6e, 0xd3, 0xee, 0xa4, 0xfa, 0xd5, 0xa5, 0x7e, 0xf6, 0xef, 0x1d,
  0x14, 0xdd, 0xf8, 0x9b, 0xba, 0x8a, 0xeb, 0x6c, 0x29, 0x8f, 0x56, 0x03, 0x36, 0xe3, 0x5c, 0x31,
  0x9d, 0x37, 0x2a, 0xa1, 0x72, 0x87, 0x23, 0xca, 0x15, 0x84, 0x55, 0x37, 0xc0, 0xbc, 0x79, 0x24,
  0x5f, 0x60, 0xdc, 0x94, 0x82, 0x03, 0x4d, 0xbc, 0xdb, 0xdb, 0x27, 0x4f, 0x09, 0x16, 0x7e, 0x18,
  0x3f, 0xa0, 0xd6, 0x4c, 0xae, 0xa5, 0x67, 0x06, 0x7d, 0xbb, 0x8e, 0xec, 0xaf, 0x9e, 0xad, 0xdb,
  0x6d, 0xd7, 0x7a, 0x93, 0xd8, 0xbb, 0xd4, 0xae, 0x67, 0x71, 0xe5, 0xe1, 0x79, 0xd3, 0x40, 0xc6,
  0xb2, 0x98, 0x8d, 0xc6, 0x6f, 0x57, 0xd3, 0x79, 0x74, 0x7f, 0xa0, 0x81, 0xa4, 0xfd, 0x2f, 0x00,
  0x20, 0x83, 0xee, 0x9f, 0x9f, 0x5b, 0x00, 0xfd, 0x3f, 0x57, 0x34, 0xb0, 0x12, 0x9f, 0x6f, 0x5a,
  0xff, 0xaf, 0x9d, 0x43, 0x7a, 0x4c, 0x07, 0x18, 0x81, 0x37, 0x8d, 0xfa, 0x5d, 0xb6, 0x39, 0x58,
  0x97, 0xda, 0xd7, 0x24, 0xb2, 0x4c, 0x1d, 0xe4, 0x4c, 0xc0, 0x93, 0x12, 0xe8, 0xcf, 0xe6, 0xbc,
  0xd7, 0x83, 0xd7, 0xc1, 0x0b, 0x71, 0xcd, 0xf3, 0x68, 0xbb, 0xe9, 0x54, 0x3d, 0x4b, 0x11, 0x83,
  0x44, 0x0f, 0x06, 0xd9, 0xa7, 0x90, 0xd9, 0x2f, 0x6f, 0xcc, 0xe6, 0xcc, 0xb2, 0x09, 0xba, 0xa7,
  0xc4, 0x12, 0xa8, 0xc7, 0x7c, 0xb1, 0x08, 0x3d, 0x82, 0xce, 0x1e, 0x35, 0x25, 0x8c, 0xb1, 0xa7,
  0x03, 0x51, 0x48, 0xe8, 0xf6, 0xb0, 0xdf, 0xed, 0x61, 0xeb, 0x7c, 0x5c, 0xaf, 0xd4, 0x6d, 0xc9,
  0x9a, 0x2f, 0x2a, 0xdd, 0x16, 0x4a, 0x30, 0xd1, 0x5c, 0x60, 0xa2, 0x87, 0xd5, 0x6e, 0x87, 0x46,
  0xb6, 0x66, 0xb9, 0xec, 0xe0, 0x4b, 0x3d, 0x03, 0xd4, 0x7d, 0x70, 0x2d, 0xeb, 0x69, 0x1b, 0x4d,
  0xf4, 0xc3, 0x7d, 0xc8, 0xa1, 0x6a, 0x83, 0x3e, 0xf2, 0x79, 0x04, 0x96, 0x2a, 0xf0, 0x70, 0x7c,
  0xf5, 0x73, 0x04, 0x98, 0x55, 0xd0, 0x08, 0x11, 0xd2, 0xfa, 0xd5, 0xce, 0xa0, 0xdd, 0x96, 0x25,
  0x6a, 0x3f, 0x16, 0xc8, 0x06, 0x93, 0x00, 0xa5, 0x16, 0x36, 0x70, 0x14, 0x40, 0xc7, 0x72, 0xe9,
  0x3c, 0xd0, 0xb2, 0xb9, 0x74, 0xf1, 0x94, 0x42, 0xbc, 0x18, 0x30, 0xdb, 0xed, 0x78, 0x89, 0xbb,
  0xaf, 0xcf, 0xb4, 0x8c, 0x0a, 0xd0, 0x37, 0xbb, 0x6d, 0xd8, 0xed, 0x84, 0xd3, 0xc3, 0x56, 0xb5,
  0x5a, 0xdd, 0x30, 0x2a, 0x43, 0x89, 0xd7, 0xf7, 0xcd, 0x84, 0x76, 0x4d, 0xef, 0xdc, 0xae, 0x0f,
  0x6c, 0xa4, 0x6f, 0x26, 0x34, 0xad, 0x6d, 0x54, 0xe9, 0xdc, 0xc1, 0xe7, 0xf8, 0x83, 0xb5, 0xf8,
  0x96, 0xe5, 0xe0, 0x43, 0xa2, 0x0b, 0xa8, 0x60, 0x6c, 0xc1, 0x1f, 0x2e, 0x72, 0x33, 0x35, 0x89,
  0x58, 0x6f, 0x15, 0xd8, 0x58, 0x35, 0x3f, 0x3d, 0xbd, 0xb1, 0x58, 0x2d, 0x1a, 0xcb, 0xba, 0x70,
  0xe2, 0x29, 0xfb, 0x0c, 0x98, 0x1b, 0x9a, 0x44, 0x70, 0x0a, 0x10, 0x58, 0x15, 0x87, 0x15, 0x76,
  0xf7, 0x30, 0x78, 0x2d, 0x5b, 0x63, 0x51, 0x02, 0xf0, 0x7a, 0x81, 0x36, 0x67, 0x9a, 0xc0, 0x7e,
  0x2e, 0x2a, 0xf7, 0xae, 0x29, 0x4c, 0x10, 0x4a, 0x90, 0xbb, 0x97, 0xd8, 0x08, 0xd5, 0x3d, 0x36,
  0xb4, 0x5a, 0xdb, 0xb6, 0xfa, 0xf8, 0xdc, 0x1d, 0xb8, 0xc1, 0x8f, 0x38, 0xa9, 0x00, 0x4c, 0x38,
  0xec, 0x90, 0x09, 0x0b, 0xa7, 0x02, 0xe2, 0xcb, 0x20, 0x41, 0x9f, 0x12, 0xe1, 0x02, 0x14, 0xda,
  0x36, 0x70, 0xff, 0xc6, 0x6a, 0x57, 0x07, 0xee, 0xf2, 0x00, 0x74, 0x1d, 0x96, 0xd4, 0x60, 0x39,
  0x57, 0x36, 0xcb, 0x39, 0xa5, 0x90, 0x93, 0xd8, 0x2a, 0xbb, 0x40, 0xad, 0x36, 0xeb, 0x50, 0xb3,
  0xce, 0xf2, 0xc0, 0x89, 0x6f, 0x76, 0xd3, 0xcd, 0xc5, 0xb7, 0x8b, 0x77, 0xa9, 0x0c, 0xb5, 0x34,
  0x36, 0x09, 0xaf, 0xa7, 0xa7, 0xe1, 0x8f, 0x04, 0x41, 0x9c, 0xeb, 0x39, 0xfe, 0x19, 0x31, 0x76,
  0xc5, 0xaa, 0x0a, 0xbe, 0xe0, 0xf0, 0xdb, 0x8e, 0xcb, 0xa0, 0xfc, 0x81, 0xda, 0x38, 0xa3, 0x4f,
  0x0f, 0xf0, 0x81, 0x66, 0x8f, 0x3f, 0x1c, 0xfc, 0xe1, 0xf0, 0x1f, 0xeb, 0xf0, 0x23, 0x95, 0x34,
  0x61, 0xba, 0x4f, 0x69, 0x2c, 0x8f, 0x2f, 0x22, 0xcd, 0x1d, 0xfe, 0x07, 0x1a, 0x24, 0x0c, 0x1d,
  0x1a, 0xa7, 0xa9, 0x08, 0x6a, 0x41, 0x5b, 0xc8, 0x30, 0x69, 0x98, 0x9e, 0xa3, 0x73, 0xc2, 0xa1,
  0x8c, 0xf0, 0x18, 0x2b, 0x64, 0xbd, 0x5b, 0x67, 0x67, 0x66, 0x0c, 0xbb, 0xf7, 0x8a, 0xd7, 0xee,
  0xdb, 0x7b, 0x41, 0x6c, 0xea, 0x8c, 0xe3, 0xb6, 0xbc, 0x7e, 0x6f, 0x2f, 0xe3, 0x17, 0x18, 0x3e,
  0x15, 0x90, 0x78, 0x2c, 0x8a, 0x21, 0x1e, 0x8f, 0x0d, 0x42, 0xa4, 0xe3, 0x26, 0x8d, 0x8b, 0xfb,
  0xa2, 0x88, 0x13, 0x58, 0xbc, 0x27, 0x87, 0x72, 0x7d, 0x74, 0x84, 0x18, 0xa0, 0xc8, 0x31, 0x51,
  0x5b, 0xf0, 0x4b, 0x74, 0x24, 0x15, 0xa6, 0x0d, 0x30, 0xba, 0xe0, 0x02, 0x59, 0x50, 0x0d, 0x09,
  0xfa, 0xe3, 0xcf, 0x3e, 0x09, 0x79, 0xa5, 0x61, 0x9c, 0x1f, 0x7d, 0x86, 0x86, 0x72, 0x12, 0xa7,
  0x7a, 0xaa, 0x12, 0x44, 0x38, 0xd6, 0x58, 0xb0, 0x2d, 0xa0, 0x1e, 0xe9, 0x7c, 0xd1, 0xa4, 0x33,
  0x53, 0x89, 0x1b, 0x78, 0xfb, 0x2b, 0xef, 0xaa, 0x72, 0x01, 0x77, 0x8b, 0xeb, 0x2b, 0x13, 0x21,
  0xaf, 0x8c, 0x4e, 0x42, 0xd1, 0x99, 0x0c, 0x3f, 0x97, 0x27, 0x28, 0x13, 0x46, 0x56, 0x6a, 0x7f,
  0xbd, 0xfa, 0xac, 0xd1, 0x41, 0x6a, 0x7d, 0xd3, 0x1d, 0x43, 0x05, 0xa6, 0xa7, 0x93, 0xbf, 0x4f,
  0x44, 0x0b, 0xa2, 0x29, 0x81, 0xc4, 0x3e, 0x7d, 0x9a, 0xe0, 0x13, 0x04, 0x41, 0x0d, 0x06, 0xeb,
  0x3e, 0xea, 0x4e, 0x00, 0xf9, 0xf1, 0xec, 0x4a, 0x8a, 0x92, 0x68, 0x44, 0x40, 0xa2, 0x1c, 0x89,
  0x31, 0xc4, 0x7b, 0x1e, 0x72, 0xfd, 0x30, 0x00, 0x8d, 0x4f, 0xd2, 0x99, 0x9e, 0xce, 0x0b, 0x8f,
  0x84, 0x20, 0x64, 0x06, 0x2e, 0xa2, 0x6e, 0x78, 0x64, 0x67, 0xaf, 0x44, 0x67, 0xd3, 0x7d, 0x22,
  0x69, 0x62, 0xe2, 0x7d, 0x4a, 0xed, 0x0d, 0x57, 0x0c, 0xb1, 0xab, 0xa9, 0x3d, 0xa2, 0x81, 0xf1,
  0xdc, 0x58, 0x82, 0x29, 0xb1, 0x84, 0x8d, 0x24, 0x72, 0x11, 0x73, 0x99, 0xd0, 0xb7, 0x00, 0x26,
  0x11, 0x59, 0xf5, 0x36, 0x98, 0x24, 0x58, 0xc1, 0xdf, 0xc6, 0xd8, 0x6a, 0xe2, 0xea, 0xa9, 0x10,
  0xae, 0xb0, 0x92, 0x41, 0x55, 0xa3, 0x2d, 0x9a, 0xfb, 0x62, 0x49, 0x2d, 0xb9, 0xba, 0xd2, 0x95,
  0x4c, 0x66, 0x38, 0xcc, 0x66, 0xb3, 0x7a, 0xc5, 0x11, 0x06, 0x57, 0xb2, 0xdb, 0xf9, 0x6a, 0x2f,
  0x3b, 0x08, 0xe7, 0xa0, 0xc0, 0x87, 0xd2, 0xc7, 0xe9, 0xeb, 0xb1, 0xe8, 0xe7, 0x4a, 0xfa, 0x39,
  0x39, 0x6d, 0xbd, 0xfe, 0xd7, 0x3a, 0xb7, 0x1a, 0x26, 0x90, 0xff, 0xcb, 0x1a, 0x1f, 0x17, 0xbb,
  0x49, 0xf9, 0x90, 0x42, 0x35, 0xef, 0x90, 0xd3, 0x20, 0xbb, 0x09, 0x16, 0x77, 0xd9, 0x74, 0xf7,
  0x1a, 0xbb, 0x8f, 0x4a, 0xfe, 0x51, 0x0f, 0xd8, 0xa5, 0xd2, 0xa8, 0x09, 0xb1, 0xf4, 0x6c, 0x6c,
  0x42, 0x11, 0xd8, 0x0b, 0x3a, 0xb6, 0x85, 0x7b, 0x9c, 0xed, 0xdb, 0xa8, 0x24, 0xa4, 0x8c, 0x74,
  0xae, 0xe8, 0xf9, 0x0a, 0x0d, 0x6d, 0x74, 0x95, 0x8a, 0x1b, 0x3b, 0xde, 0x8f, 0xbc, 0x4e, 0xfe,
  0x92, 0x77, 0x29, 0xe3, 0xd3, 0x4e, 0x44, 0xef, 0xdc, 0xbc, 0x16, 0xc1, 0x91, 0x92, 0x5a, 0xfd,
  0x9c, 0xee, 0xc3, 0x51, 0xf0, 0x82, 0x3b, 0xa3, 0x5b, 0x7f, 0xa7, 0xef, 0x5e, 0xc1, 0xf8, 0x29,
  0xbb, 0x97, 0x92, 0x3a, 0x60, 0x20, 0x8b, 0xb2, 0xf3, 0xa7, 0x31, 0x6e, 0x70, 0xb2, 0x4b, 0x1a,
  0x0f, 0x1f, 0x84, 0x0f, 0xfb, 0xf6, 0xa4, 0xbb, 0x23, 0xc3, 0x78, 0x4a, 0x13, 0x22, 0x0a, 0xd3,
  0xc7, 0xb8, 0xa0, 0xe1, 0xc7, 0x4f, 0x84, 0xb2, 0x18, 0x8a, 0x04, 0x63, 0x30, 0x8d, 0xee, 0xc1,
  0x0f, 0x39, 0x5a, 0x11, 0xfb, 0xc9, 0xe3, 0x15, 0xd1, 0x8f, 0x19, 0x74, 0x46, 0xd3, 0xd3, 0x72,
  0x7d, 0xcf, 0xec, 0x48, 0xc3, 0xa3, 0xd3, 0x1d, 0x14, 0x64, 0xfe, 0xf9, 0x0b, 0xed, 0xaf, 0xcb,
  0x2b, 0x56, 0xdd, 0x8b, 0xb7, 0xe4, 0x45, 0x1f, 0x83, 0xea, 0xf0, 0xf9, 0x23, 0xf8, 0x5c, 0x34,
  0x5f, 0x60, 0xa1, 0x51, 0xc8, 0x99, 0x50, 0xa3, 0xab, 0xe5, 0x37, 0x77, 0xaf, 0xb1, 0x02, 0xff,
  0x08, 0x05, 0x7e, 0xda, 0xed, 0xd6, 0x85, 0x2d, 0x8b, 0x47, 0x2e, 0xa3, 0x88, 0x5a, 0xc8, 0x1d,
  0xa8, 0xd4, 0x87, 0xbf, 0xc4, 0x52, 0x7d, 0x77, 0xbf, 0xb8, 0x83, 0x8e, 0x3e, 0xb1, 0x14, 0x12,
  0x45, 0x38, 0xd1, 0x52, 0xb5, 0xfd, 0xf2, 0x28, 0xab, 0xcc, 0x38, 0xb1, 0x8a, 0xc3, 0x55, 0xdc,
  0x53, 0x5c, 0xab, 0x76, 0xb6, 0xcd, 0xac, 0x1c, 0x29, 0xf7, 0xac, 0xe1, 0x63, 0xd5, 0x59, 0x44,
  0xab, 0xd5, 0x32, 0x62, 0x2e, 0x3f, 0x34, 0xd0, 0xc9, 0x60, 0xfe, 0x31, 0xac, 0x9b, 0x30, 0xed,
  0xcb, 0xd8, 0x1d, 0xac, 0x78, 0x18, 0xb4, 0xeb, 0xed, 0x6d, 0xef, 0x97, 0xd7, 0xc8, 0x9f, 0xae,
  0xff, 0x3f, 0x37, 0x99, 0x0f, 0xf6, 0x03, 0x06, 0xc7, 0xc1, 0x8a, 0x6f, 0x28, 0x15, 0xdf, 0x90,
  0x2a, 0x7e, 0xf8, 0x3e, 0x43, 0x82, 0x47, 0x14, 0x96, 0x82, 0x6e, 0x79, 0x46, 0xf4, 0x3b, 0xfd,
  0x86, 0xd2, 0xd7, 0x0c, 0xab, 0xe7, 0x75, 0xe8, 0x05, 0x83, 0x09, 0xb7, 0xc2, 0xbd, 0x6f, 0xdc,
  0xb3, 0x92, 0x1b, 0xc2, 0xe8, 0x57, 0x14, 0xf6, 0xe2, 0x9e, 0x1a, 0xc8, 0x63, 0x46, 0x0e, 0xd7,
  0xf1, 0x81, 0x44, 0xbe, 0xd8, 0x72, 0xc6, 0x43, 0x36, 0x8c, 0x52, 0x91, 0x98, 0x5d, 0x5a, 0xf9,
  0xaa, 0xba, 0x0b, 0x59, 0xf6, 0x53, 0xd1, 0x88, 0x9c, 0x1a, 0xd3, 0x6a, 0x65, 0xdb, 0xb2, 0x53,
  0x3b, 0xb5, 0xbc, 0xec, 0x93, 0x51, 0xd9, 0x53, 0x11, 0x6d, 0x4b, 0x04, 0x96, 0xb2, 0x9d, 0x69,
  0xf9, 0xf4, 0x81, 0x2d, 0xfe, 0x7b, 0xc9, 0x5c, 0xd6, 0xd1, 0xd5, 0x50, 0x1f, 0x7a, 0xaf, 0x86,
  0xb8, 0xb8, 0x3b, 0xb3, 0xcc, 0xcb, 0xf2, 0x74, 0xf9, 0x34, 0x60, 0x3d, 0x8a, 0x07, 0xc0, 0x97,
  0xb5, 0x14, 0x16, 0x22, 0x11, 0x63, 0xd0, 0xb7, 0x57, 0xad, 0xf5, 0x5e, 0xdb, 0x76, 0xb6, 0xb7,
  0xcd, 0xe1, 0xec, 0xbc, 0x71, 0xba, 0x92, 0x2c, 0x05, 0x05, 0xb2, 0x8c, 0x19, 0xb2, 0xb5, 0x52,
  0xbe, 0xe8, 0x20, 0x62, 0xdc, 0x60, 0x34, 0x7f, 0xf4, 0x26, 0x1f, 0x7d, 0x39, 0xfa, 0x62, 0xf4,
  0x09, 0x50, 0xa7, 0x2f, 0x46, 0x9f, 0xe2, 0xc5, 0xe3, 0x7f, 0x19, 0xfd, 0x07, 0x3c, 0x7e, 0x3c,
  0xfa, 0xd7, 0xf0, 0xe5, 0x3c, 0xe1, 0x7b, 0x4f, 0x39, 0xcb, 0x54, 0x27, 0x79, 0xb4, 0x28, 0xf3,
  0x23, 0x6b, 0xb2, 0x2e, 0x57, 0xab, 0xf9, 0x62, 0x71, 0x39, 0x11, 0x90, 0xcb, 0x1e, 0x4a, 0xe3,
  0xfa, 0x6e, 0x6f, 0x27, 0x16, 0x1e, 0xc6, 0x8e, 0x06, 0x33, 0xf0, 0x26, 0xdd, 0x08, 0xf9, 0x7f,
  0xaf, 0x4a, 0xfe, 0xc1, 0x65, 0x3c, 0xc9, 0x16, 0x5b, 0x36, 0xd4, 0xfe, 0xeb, 0x0e, 0xc1, 0xeb,
  0xee, 0x2f, 0xe9, 0x7d, 0xb6, 0x0f, 0x42, 0xee, 0xf0, 0x85, 0xd8, 0x4b, 0x89, 0xd2, 0x31, 0x32,
  0xd9, 0xb0, 0xcc, 0x34, 0xfe, 0x2f, 0x9b, 0x2f, 0x1a, 0x93, 0x24, 0xe4, 0x8c, 0x4a, 0x38, 0x29,
  0x5f, 0x70, 0xdc, 0x43, 0x50, 0xe5, 0xa4, 0xfb, 0x8d, 0x79, 0x4a, 0xea, 0x18, 0x48, 0x06, 0x3d,
  0x8f, 0x57, 0x7b, 0x80, 0x25, 0x7f, 0x0e, 0xda, 0xdf, 0x8d, 0xd1, 0x57, 0xa3, 0xff, 0x50, 0x2f,
  0xd3, 0xc5, 0xf6, 0x9e, 0xcb, 0x9a, 0xe1, 0x80, 0x43, 0xc1, 0x2c, 0xc9, 0xb8, 0xe1, 0x0c, 0xbb,
  0x86, 0xc1, 0x66, 0xe1, 0xc3, 0x59, 0xe0, 0xc1, 0x16, 0x20, 0xe6, 0xf2, 0xe9, 0xb8, 0x3b, 0x0f,
  0xb1, 0xd9, 0x9b, 0xf1, 0xca, 0x03, 0xa5, 0xfd, 0x90, 0x9a, 0xe1, 0x70, 0x70, 0x1a, 0x11, 0x4a,
  0xb9, 0xbc, 0xb8, 0x67, 0xf4, 0x08, 0xdb, 0xb1, 0x38, 0x04, 0x57, 0x42, 0x5c, 0xfd, 0x2f, 0xf8,
  0x1e, 0x89, 0xef, 0x71, 0xf4, 0xf1, 0xbf, 0x87, 0x04, 0x3c, 0x29, 0xa2, 0xab, 0xe7, 0x5c, 0x1e,
  0x17, 0x9a, 0x92, 0x63, 0xdd, 0xf9, 0x96, 0xc8, 0x02, 0x77, 0x8e, 0x9f, 0x82, 0xe2, 0x8a, 0x41,
  0xa6, 0xa0, 0x55, 0xb5, 0x7a, 0x96, 0x67, 0x6d, 0x94, 0x39, 0x04, 0x6c, 0x0e, 0x7d, 0x8b, 0xf5,
  0x65, 0x90, 0x12, 0x3d, 0x1a, 0x1e, 0x93, 0xc5, 0x5a, 0x8a, 0x9c, 0x5d, 0xa8, 0xd2, 0x7a, 0x6e,
  0x6f, 0xd3, 0x13, 0xd0, 0x20, 0xbb, 0x01, 0x64, 0xa4, 0xee, 0x95, 0xd1, 0xa8, 0x23, 0xe5, 0x88,
  0xea, 0x49, 0xae, 0xef, 0x0a, 0xb2, 0x75, 0x50, 0x8d, 0x5b, 0x53, 0xce, 0xa0, 0xf7, 0x8b, 0x19,
  0x8a, 0x65, 0xc8, 0x0f, 0x2d, 0xd2, 0xf9, 0x7c, 0x7a, 0x0e, 0x48, 0x61, 0xd1, 0x23, 0x85, 0x8a,
  0x67, 0x8d, 0x95, 0xb7, 0x0a, 0x56, 0x44, 0x98, 0x1c, 0x9d, 0x67, 0x59, 0x8d, 0x21, 0x7d, 0xf3,
  0x25, 0x85, 0xf4, 0x2d, 0x00, 0xf1, 0x63, 0xbe, 0x07, 0x7e, 0x42, 0xd8, 0x41, 0xaf, 0x67, 0xf7,
  0x6b, 0x96, 0x63, 0x87, 0x69, 0xde, 0x02, 0xd1, 0x3c, 0x0f, 0xbe, 0x31, 0x9a, 0xf5, 0xaf, 0x01,
  0xf6, 0x7f, 0x0d, 0x50, 0x5f, 0xc0, 0x1b, 0x22, 0x5f, 0x8c, 0xae, 0x8a, 0xeb, 0x8d, 0x93, 0xdc,
  0x4b, 0xe6, 0xfd, 0xcb, 0xc1, 0xd9, 0xf8, 0x85, 0xc3, 0x4f, 0x6e, 0x28, 0xb2, 0x7d, 0xe0, 0x66,
  0x99, 0x92, 0x2b, 0xd1, 0xbb, 0x4f, 0xe9, 0x67, 0x71, 0xe1, 0x68, 0x0e, 0x20, 0xa8, 0x91, 0x5e,
  0xe2, 0xef, 0xa7, 0x00, 0xac, 0xda, 0x13, 0xc8, 0xe4, 0x6a, 0x0b, 0x2d, 0x7c, 0xe0, 0x72, 0x33,
  0x97, 0x8f, 0xb9, 0x14, 0xcc, 0xc5, 0xdc, 0xa8, 0x4a, 0xb8, 0xd2, 0x24, 0xcc, 0x5f, 0xa7, 0xf1,
  0xef, 0xb0, 0xdb, 0x23, 0x28, 0x9d, 0xdf, 0x20, 0x79, 0xee, 0x26, 0x8b, 0x93, 0x88, 0x2f, 0xae,
  0x72, 0xa9, 0x99, 0xff, 0xfc, 0x58, 0x91, 0x93, 0xf1, 0x65, 0x44, 0xf3, 0xb5, 0xaa, 0x98, 0xd9,
  0x49, 0xa7, 0x40, 0xc7, 0xf5, 0x6c, 0x85, 0xf5, 0xe8, 0xe1, 0x57, 0xf9, 0x2c, 0x78, 0xe1, 0xc7,
  0x9f, 0x7f, 0xa2, 0x47, 0x0f, 0xb9, 0xca, 0x47, 0xce, 0x0b, 0x4a, 0xa5, 0x7e, 0xac, 0xf8, 0x01,
  0xb4, 0xb2, 0x50, 0x1b, 0xce, 0xcd, 0x45, 0x22, 0x88, 0x14, 0x41, 0x20, 0x96, 0x47, 0x17, 0xe8,
  0xe6, 0x2e, 0x36, 0x83, 0x4b, 0x14, 0x62, 0xc2, 0x63, 0x22, 0x2b, 0x24, 0x09, 0x1f, 0x3f, 0x14,
  0x06, 0x4e, 0x32, 0x98, 0x1c, 0x0e, 0x25, 0x20, 0x7a, 0x54, 0x3c, 0x66, 0x04, 0x2b, 0x18, 0xc6,
  0x4d, 0x7c, 0x8f, 0xc3, 0x1d, 0x46, 0x76, 0x13, 0x2d, 0x8e, 0xcc, 0xcb, 0xf2, 0xd6, 0x9c, 0x35,
  0x0f, 0x93, 0x0e, 0xc9, 0x23, 0x22, 0xe2, 0x96, 0x7a, 0x13, 0x93, 0x42, 0xfb, 0x09, 0xfe, 0xc0,
  0xc3, 0x67, 0x92, 0x8f, 0xc4, 0x6d, 0x8a, 0xa1, 0xe5, 0x07, 0x9d, 0x15, 0x17, 0xc8, 0xee, 0x8e,
  0xee, 0x2b, 0x2c, 0x2d, 0x14, 0x11, 0x23, 0x20, 0xdb, 0x30, 0x55, 0x89, 0xfd, 0x1d, 0x26, 0xb0,
  0x2b, 0x4f, 0x5f, 0xba, 0x04, 0xb4, 0x47, 0xdc, 0x53, 0xa3, 0xe0, 0x82, 0x57, 0x42, 0x6c, 0xab,
  0x53, 0xf7, 0xf9, 0xd6, 0xb1, 0x7a, 0x80, 0x6f, 0x1d, 0xab, 0x8f, 0x65, 0x5c, 0x3c, 0x05, 0xb1,
  0xc2, 0xb8, 0x8e, 0xd5, 0x15, 0xce, 0xd5, 0xa9, 0x7b, 0xac, 0x8b, 0x1e, 0x63, 0x78, 0xd7, 0xb1,
  0xfa, 0x5f, 0x98, 0x57, 0x3c, 0xea, 0x7c, 0x0a, 0x92, 0xfb, 0xc7, 0x20, 0xb9, 0x7f, 0x39, 0xfa,
  0xe8, 0xcf, 0x82, 0x6b, 0x75, 0xea, 0x87, 0x9e, 0x96, 0x6d, 0x75, 0xea, 0xaf, 0x3c, 0x01, 0xdf,
  0xea, 0xd4, 0x8f, 0x3f, 0x57, 0xc6, 0xd5, 0xa9, 0x03, 0xe7, 0x12, 0xb3, 0x3b, 0x09, 0x4f, 0x89,
  0xbc, 0x8b, 0xcd, 0xa1, 0x2a, 0xe6, 0x22, 0xca, 0x47, 0xb2, 0x2f, 0x36, 0xf2, 0xaa, 0x98, 0x81,
  0x28, 0xab, 0x72, 0xb0, 0x1f, 0x27, 0x96, 0x00, 0xa1, 0x85, 0x75, 0x79, 0x26, 0x3c, 0x8c, 0xad,
  0xd4, 0x8f, 0x98, 0x89, 0x85, 0x31, 0xf1, 0xe9, 0xb9, 0x17, 0x2e, 0x5e, 0x24, 0xfb, 0x62, 0xb0,
  0xf0, 0xbc, 0xf8, 0xd7, 0x55, 0xf9, 0x56, 0xb0, 0x9a, 0x04, 0xe2, 0x07, 0x62, 0x5f, 0x12, 0xd3,
  0x7a, 0xc4, 0xc3, 0x62, 0xdd, 0xf5, 0x23, 0x6b, 0x63, 0xb0, 0x5e, 0xee, 0x0d, 0x22, 0x59, 0xfe,
  0xba, 0xbd, 0x1e, 0xa5, 0xf5, 0x89, 0x35, 0xfd, 0x75, 0x7b, 0xd2, 0xa1, 0x45, 0xb7, 0x97, 0x85,
  0x0a, 0x64, 0x8e, 0x65, 0x6c, 0x28, 0xc1, 0xad, 0x1c, 0x0a, 0x66, 0x48, 0xad, 0x0e, 0x2a, 0xd4,
  0x80, 0x84, 0xdc, 0x13, 0x79, 0x28, 0x71, 0x48, 0x28, 0xfe, 0x64, 0x44, 0xce, 0xab, 0x3e, 0x31,
  0x81, 0xf3, 0x6a, 0x1c, 0x06, 0x55, 0x97, 0x88, 0x5b, 0xc0, 0xe6, 0x1d, 0x36, 0x72, 0x47, 0x1b,
  0xb5, 0x83, 0x46, 0xec, 0xfd, 0xa1, 0x1e, 0x0e, 0x55, 0xbd, 0x79, 0x9d, 0x94, 0x16, 0x8f, 0x14,
  0x7c, 0x85, 0xcc, 0x29, 0xb3, 0xa8, 0x8a, 0xd9, 0x04, 0xeb, 0xf8, 0xa4, 0x4e, 0x99, 0x43, 0x55,
  0xcc, 0x25, 0x58, 0x9e, 0x17, 0x46, 0xe0, 0x88, 0xb0, 0x03, 0x60, 0xa6, 0x51, 0x16, 0x8f, 0xfe,
  0x9e, 0xe4, 0x2a, 0x24, 0x35, 0xdf, 0x72, 0x5e, 0xef, 0xf5, 0x8e, 0x0e, 0xe8, 0x12, 0x11, 0x6b,
  0x19, 0x0f, 0x25, 0x60, 0x2b, 0x6b, 0xed, 0x41, 0xdd, 0x76, 0x52, 0xfa, 0xdf, 0x0d, 0xcc, 0xb9,
  0xb9, 0x22, 0xfe, 0x2d, 0x94, 0xe8, 0xef, 0xbc, 0xea, 0x10, 0x83, 0xfb, 0x4f, 0x13, 0x92, 0x5a,
  0x5a, 0xd6, 0x31, 0x79, 0x9b, 0x5e, 0xd6, 0x31, 0xf5, 0x97, 0x3e, 0xc6, 0x2e, 0x13, 0x0b, 0x44,
  0xa7, 0xc7, 0x05, 0x43, 0x7d, 0x22, 0xa2, 0x5d, 0x4a, 0x24, 0xda, 0xb9, 0xf9, 0x74, 0xbe, 0x94,
  0xce, 0xce, 0xef, 0x51, 0xb2, 0x19, 0x6f, 0x17, 0xcc, 0x71, 0x7a, 0x2d, 0x96, 0x2b, 0x44, 0xa2,
  0xc6, 0x90, 0xeb, 0x58, 0x73, 0xe7, 0xd3, 0xd3, 0xea, 0xaf, 0xfc, 0xd8, 0x11, 0x2c, 0x26, 0xf7,
  0x81, 0x2d, 0x1f, 0x12, 0x86, 0xe5, 0x08, 0xce, 0x12, 0x27, 0x49, 0x05, 0x69, 0xf6, 0xbc, 0x44,
  0xb3, 0x11, 0x49, 0x54, 0x9a, 0x3d, 0xcf, 0x68, 0x36, 0x47, 0x84, 0xa1, 0xd7, 0x2d, 0xb3, 0x40,
  0x21, 0x41, 0xa5, 0x8f, 0x08, 0xf5, 0xe1, 0xd5, 0x52, 0x4c, 0x5b, 0xb2, 0x5d, 0x4a, 0xb6, 0x43,
  0x3e, 0x11, 0xe1, 0xf2, 0x4d, 0x5b, 0xd7, 0xe9, 0xb0, 0x8d, 0x8e, 0x61, 0x25, 0x72, 0x8a, 0x09,
  0x7e, 0xe3, 0x69, 0x69, 0x53, 0x22, 0xa5, 0xfb, 0x9b, 0x59, 0x2c, 0x3c, 0x3d, 0x0d, 0x0f, 0x94,
  0x11, 0xe3, 0x58, 0xd7, 0xb5, 0x13, 0xc8, 0x29, 0x16, 0x1e, 0x4b, 0x4a, 0x29, 0x1a, 0x04, 0x7e,
  0xad, 0xea, 0xfe, 0x11, 0x93, 0xd4, 0xfe, 0xf4, 0xb4, 0xf4, 0x83, 0x5f, 0x96, 0x58, 0x32, 0x7d,
  0x05, 0x03, 0xab, 0xce, 0xa8, 0x92, 0x50, 0x08, 0x0f, 0x0a, 0x07, 0xd3, 0x07, 0xc9, 0x54, 0x9f,
  0x2b, 0x19, 0x7b, 0x49, 0xbb, 0x11, 0xca, 0xe2, 0x11, 0x4e, 0x43, 0x1f, 0x17, 0x59, 0xb4, 0xd1,
  0xa8, 0xd5, 0x16, 0xcc, 0x70, 0x34, 0xfb, 0x03, 0x5b, 0xd2, 0x74, 0x86, 0x0a, 0x7f, 0x1c, 0xfa,
  0xb3, 0xc7, 0x95, 0x4b, 0x9c, 0xa2, 0xcc, 0xf0, 0x17, 0x14, 0x86, 0x5f, 0xb2, 0x8a, 0x56, 0x08,
  0x33, 0x72, 0x50, 0x22, 0x2a, 0x0c, 0xe2, 0x75, 0x10, 0x69, 0x40, 0x8e, 0x01, 0x41, 0xe0, 0xa3,
  0xf8, 0x50, 0x8c, 0xd2, 0x0c, 0xe7, 0xa4, 0xae, 0x6a, 0xa5, 0x7a, 0xa3, 0x56, 0x8a, 0x9e, 0x21,
  0x8e, 0x3f, 0x76, 0x72, 0xcc, 0x90, 0x8f, 0xfb, 0xca, 0x9e, 0xfc, 0x4d, 0x9d, 0x6c, 0xc2, 0x81,
  0x20, 0x49, 0x07, 0x41, 0xc6, 0x09, 0x04, 0x49, 0x12, 0x1b, 0xe7, 0xfd, 0xe6, 0x5b, 0x8b, 0x3f,
  0xfd, 0x7d, 0x67, 0x1e, 0xdd, 0x73, 0xe4, 0x86, 0x7c, 0x90, 0x9d, 0xe3, 0xa0, 0x68, 0x74, 0x43,
  0x5b, 0xb4, 0xd7, 0x69, 0x16, 0xde, 0x89, 0x03, 0xfc, 0x56, 0x26, 0x43, 0xd3, 0xa8, 0xb7, 0xfa,
  0x38, 0x07, 0xf8, 0x67, 0xcf, 0x13, 0x08, 0x86, 0xbc, 0x5b, 0x33, 0xe5, 0x09, 0x14, 0x99, 0x82,
  0xf6, 0x87, 0xff, 0x83, 0x77, 0x29, 0xb1, 0xfd, 0xe1, 0x64, 0x27, 0x1c, 0x91, 0xe8, 0x76, 0x3a,
  0xf9, 0x1c, 0x2b, 0x26, 0x70, 0x32, 0x73, 0xd1, 0x9e, 0x4f, 0xcf, 0x9b, 0xe9, 0x82, 0x89, 0xec,
  0x23, 0xcd, 0x11, 0x29, 0x5d, 0xc8, 0xa7, 0xe7, 0xe7, 0xf0, 0x4d, 0x24, 0x47, 0xb1, 0xe7, 0xac,
  0x50, 0x4a, 0x51, 0x42, 0x1c, 0x2f, 0x1e, 0xfa, 0x5c, 0x4c, 0x3c, 0x74, 0xf9, 0x84, 0xcc, 0x8b,
  0xda, 0x4a, 0x9c, 0x4f, 0xe6, 0x8a, 0x94, 0xdc, 0xc0, 0xc1, 0xb0, 0x2c, 0x93, 0xf0, 0xa8, 0x02,
  0xd1, 0x6f, 0xaa, 0xd2, 0xec, 0xb7, 0x3a, 0x67, 0xcb, 0xca, 0x32, 0xe7, 0x78, 0xaa, 0xde, 0x1b,
  0x93, 0x70, 0xae, 0x03, 0x5b, 0xb4, 0xa4, 0xc3, 0x38, 0x3a, 0xcd, 0x08, 0xec, 0x57, 0xa4, 0x5d,
  0x7e, 0x3f, 0xba, 0x4b, 0xe1, 0x92, 0xc9, 0xd5, 0xf9, 0x51, 0xa6, 0xa0, 0x24, 0x35, 0xc1, 0xc4,
  0xe5, 0xb2, 0xb4, 0xb1, 0x96, 0x64, 0x61, 0x61, 0x2e, 0x3a, 0x4e, 0xc0, 0xc2, 0xd2, 0xcc, 0xf2,
  0xf7, 0x78, 0xbb, 0xc1, 0xfb, 0xe1, 0x01, 0x21, 0xbe, 0x6d, 0xac, 0x79, 0xd4, 0x03, 0xe9, 0x6b,
  0xbf, 0xbb, 0xe9, 0x54, 0x7d, 0x45, 0xd2, 0xaf, 0x23, 0x7c, 0xcf, 0x1a, 0x82, 0xca, 0xf3, 0x99,
  0x74, 0xec, 0x33, 0x7e, 0x04, 0x23, 0x7e, 0xfa, 0x71, 0x8b, 0xc4, 0x2e, 0x54, 0x15, 0x52, 0x74,
  0x09, 0x91, 0x67, 0x5c, 0x17, 0xf1, 0x39, 0x95, 0x59, 0x1a, 0x69, 0x6a, 0x42, 0x0a, 0x4a, 0x74,
  0x87, 0x72, 0xeb, 0xdc, 0xf6, 0x5a, 0x78, 0x44, 0x6e, 0xe0, 0x77, 0xe5, 0x16, 0x8c, 0x80, 0x42,
  0xdc, 0x72, 0x8e, 0xd9, 0x67, 0x60, 0x79, 0x1a, 0x59, 0x68, 0x4b, 0xdb, 0x5f, 0xad, 0xf2, 0x60,
  0x5e, 0xb4, 0xd4, 0x94, 0x1f, 0x08, 0x9d, 0x84, 0xee, 0x93, 0xa3, 0xc0, 0x7b, 0x59, 0x8d, 0xc6,
  0xeb, 0x07, 0x28, 0x7b, 0x44, 0xe9, 0xc4, 0x6e, 0x73, 0xaf, 0x0d, 0x8c, 0xd0, 0x44, 0x99, 0x1e,
  0xaf, 0x06, 0x3a, 0x59, 0xb3, 0xd8, 0xe1, 0x1f, 0xf4, 0x43, 0xfd, 0x49, 0x62, 0xc1, 0xb2, 0x96,
  0x6a, 0x64, 0x7b, 0x4b, 0xd5, 0x79, 0x73, 0xd9, 0x13, 0xef, 0xcb, 0xf4, 0xa6, 0x80, 0x6f, 0xb8,
  0x98, 0x5f, 0xd6, 0x45, 0x5a, 0x07, 0x43, 0xaa, 0x5b, 0x96, 0xeb, 0x72, 0x35, 0x40, 0xaa, 0xcb,
  0xdd, 0x97, 0xa0, 0x6e, 0x29, 0x57, 0x5b, 0x28, 0xcd, 0x89, 0xdd, 0xf5, 0xc7, 0xd5, 0xc3, 0xe0,
  0xcb, 0xd2, 0xb8, 0x60, 0x34, 0xec, 0x0a, 0x45, 0xc9, 0xd4, 0xa1, 0x75, 0xd0, 0x28, 0x8a, 0x75,
  0xd0, 0xed, 0x24, 0xe3, 0x00, 0x6e, 0x32, 0xdd, 0x9b, 0xea, 0x2b, 0xb2, 0x8d, 0x5b, 0x17, 0xb0,
  0xac, 0xc4, 0x04, 0x05, 0xcc, 0xd2, 0xf0, 0xc1, 0x8c, 0xe5, 0x60, 0x9c, 0xbe, 0x47, 0xa5, 0xa6,
  0x07, 0xb1, 0x2f, 0x8b, 0x74, 0xd1, 0xad, 0x4f, 0xd0, 0x95, 0x29, 0xe5, 0x00, 0xd6, 0xe3, 0x55,
  0xd8, 0xd8, 0x3b, 0xda, 0x82, 0x8e, 0x20, 0x85, 0xf0, 0xae, 0xd8, 0x37, 0x5b, 0xf5, 0xba, 0xdd,
  0xa9, 0x08, 0xbe, 0x33, 0x17, 0x30, 0x33, 0x04, 0x1b, 0x67, 0x23, 0xc0, 0x61, 0xf7, 0x86, 0x4a,
  0xe0, 0x5d, 0xba, 0x17, 0xc5, 0xfc, 0x16, 0xbc, 0xc6, 0x28, 0x36, 0x6f, 0xa8, 0x6b, 0x12, 0x40,
  0xd9, 0xa5, 0x72, 0x6a, 0x4d, 0xcb, 0xce, 0xa9, 0xa1, 0x40, 0x63, 0x54, 0x60, 0x7c, 0x31, 0xd9,
  0x3a, 0xd1, 0x7e, 0x04, 0x65, 0x0a, 0x7f, 0x43, 0x0e, 0x6c, 0x09, 0x98, 0x18, 0xc6, 0x6e, 0x4a,
  0x0f, 0x0f, 0x35, 0xe5, 0xde, 0xe0, 0x57, 0x5f, 0xd2, 0xbf, 0x3d, 0x30, 0x6b, 0xac, 0xc5, 0x99,
  0x91, 0xc2, 0xc2, 0x93, 0xa0, 0xf9, 0x0b, 0x46, 0x6c, 0x6a, 0xe8, 0x44, 0x92, 0x9f, 0x8f, 0x27,
  0xf9, 0x7a, 0x0c, 0xd5, 0x8d, 0x91, 0x6e, 0xb8, 0xfb, 0xc3, 0x78, 0xe9, 0x86, 0xc5, 0xb4, 0xff,
  0x0a, 0xa4, 0x9b, 0xeb, 0x98, 0x4e, 0xec, 0xa3, 0xd1, 0x6f, 0xe9, 0xc7, 0x97, 0xa3, 0x7f, 0x8e,
  0x3f, 0xf1, 0xc6, 0x8d, 0xb1, 0xd6, 0xda, 0x76, 0x54, 0xa4, 0x66, 0x2f, 0xc9, 0x4b, 0xdb, 0xea,
  0x39, 0x76, 0x59, 0x3c, 0xe0, 0xa2, 0x23, 0xda, 0x21, 0x2a, 0x60, 0xd5, 0x48, 0xc6, 0xc0, 0x2d,
  0xa4, 0x40, 0xb8, 0x91, 0x2a, 0xab, 0x2b, 0x0f, 0x34, 0x59, 0x1b, 0x4e, 0x2e, 0xe6, 0xc7, 0x09,
  0xd4, 0xd0, 0xf6, 0x64, 0x3c, 0xc4, 0x98, 0xac, 0x58, 0x9c, 0x02, 0x41, 0x19, 0x8c, 0xd9, 0x1d,
  0x50, 0xdf, 0xef, 0xaf, 0xf6, 0xfa, 0xc0, 0x05, 0x2a, 0x95, 0x62, 0x97, 0xe7, 0xf0, 0x07, 0x92,
  0x6a, 0xcf, 0xc8, 0xcf, 0xae, 0xe0, 0xc9, 0x9f, 0x32, 0x07, 0x0f, 0x1e, 0x54, 0xdf, 0x2e, 0x69,
  0x99, 0xa2, 0x29, 0x7a, 0xc9, 0x64, 0x32, 0xf2, 0xb1, 0xc6, 0x75, 0x39, 0x9b, 0xd8, 0x1d, 0x91,
  0xd8, 0x6e, 0x0a, 0x93, 0x9f, 0x85, 0x8c, 0xd6, 0x50, 0xd5, 0x1b, 0xd7, 0x89, 0xd7, 0x5e, 0xaf,
  0x6e, 0x99, 0x65, 0x71, 0x83, 0x61, 0xf4, 0x9f, 0xe4, 0x47, 0xf6, 0x50, 0x4f, 0xe7, 0x50, 0x8d,
  0xff, 0xe0, 0x77, 0xd2, 0xc5, 0x7b, 0x0a, 0xd3, 0x89, 0x0e, 0x7d, 0x98, 0x6e, 0x86, 0x15, 0xca,
  0x43, 0xc5, 0x7f, 0xb9, 0xac, 0x8d, 0x3e, 0x23, 0x3b, 0x09, 0x4b, 0x3b, 0x05, 0xaf, 0x0b, 0xd8,
  0xde, 0x45, 0x6a, 0xef, 0xdf, 0xc8, 0x72, 0x7e, 0x81, 0x15, 0x9f, 0x2b, 0x52, 0xa3, 0xff, 0x0e,
  0x22, 0x00, 0x65, 0x38, 0xd8, 0x19, 0x3d, 0x80, 0x97, 0x25, 0xf1, 0xf2, 0x5d, 0x0a, 0xcc, 0xf9,
  0x9d, 0x9e, 0x2e, 0xb2, 0xce, 0x7f, 0x8f, 0x0d, 0x5f, 0x40, 0x5e, 0x85, 0x1e, 0x92, 0xc5, 0x42,
  0xe8, 0x25, 0x63, 0x5f, 0x78, 0xe1, 0x96, 0x7b, 0x51, 0x16, 0x59, 0x07, 0x7f, 0x90, 0xcb, 0x50,
  0x0c, 0x3f, 0x96, 0x94, 0x0d, 0x4a, 0xcc, 0xe7, 0x44, 0x09, 0xf2, 0x73, 0x60, 0xe1, 0x11, 0x25,
  0x63, 0xf7, 0x7c, 0x41, 0xfd, 0xae, 0xf4, 0xc0, 0x4a, 0x14, 0x43, 0x2d, 0xdc, 0xf5, 0x93, 0xbe,
  0xe9, 0xe9, 0x05, 0xe8, 0x81, 0xdf, 0x14, 0x19, 0xdd, 0xa0, 0x19, 0x7d, 0x1d, 0xea, 0x65, 0xa1,
  0x10, 0x2e, 0x13, 0xee, 0x69, 0xa1, 0x18, 0xd9, 0x92, 0xd2, 0x5b, 0xc9, 0x14, 0xab, 0xf2, 0xa9,
  0xc8, 0x8a, 0x0d, 0x2f, 0xbd, 0x49, 0x7a, 0x2f, 0x95, 0xe6, 0xd1, 0xf0, 0x55, 0xa2, 0xbd, 0x7b,
  0x9f, 0x27, 0x42, 0x14, 0xa5, 0xfc, 0xe6, 0xa9, 0x0c, 0x9b, 0xea, 0x1f, 0xbd, 0xee, 0x59, 0x3e,
  0x2e, 0x04, 0x30, 0xbf, 0xaf, 0x79, 0x51, 0x46, 0x69, 0x85, 0x8a, 0xef, 0x5e, 0xd2, 0xd3, 0x07,
  0x8b, 0x7e, 0x3f, 0x9f, 0x10, 0x20, 0xde, 0xc1, 0x7d, 0x38, 0x38, 0x1f, 0xf1, 0x9a, 0xa0, 0xf5,
  0x6b, 0xae, 0x7c, 0x3f, 0xc4, 0xcb, 0x8d, 0x07, 0x0f, 0x46, 0x15, 0x53, 0xb6, 0x74, 0x28, 0xd0,
  0xee, 0x2a, 0x4f, 0x34, 0x4a, 0x29, 0x36, 0x82, 0x71, 0x27, 0xb5, 0x54, 0x3e, 0x57, 0x36, 0xcd,
  0x8c, 0x39, 0x5f, 0xc6, 0x5c, 0x80, 0x4c, 0x26, 0xa2, 0xd4, 0x62, 0x1f, 0xfa, 0x81, 0x32, 0x31,
  0x32, 0xec, 0x15, 0xe1, 0x21, 0x2c, 0x9d, 0xec, 0xf0, 0x34, 0x6a, 0xbc, 0x65, 0x96, 0x76, 0x77,
  0x87, 0x84, 0x54, 0xe6, 0x68, 0x7c, 0x57, 0x46, 0xa7, 0x9f, 0x1f, 0x7b, 0xe5, 0xa7, 0x47, 0x8f,
  0x13, 0x52, 0xc1, 0xba, 0xfc, 0x46, 0x1b, 0x7d, 0xce, 0x07, 0xc4, 0xa3, 0x52, 0xdc, 0xf4, 0xb1,
  0xeb, 0x37, 0x0a, 0x7e, 0x48, 0xa9, 0x7d, 0x09, 0xb3, 0x58, 0x01, 0x05, 0xb5, 0xe4, 0x22, 0x43,
  0xc5, 0x6d, 0x16, 0x08, 0xd5, 0x89, 0xf5, 0x2e, 0x73, 0xd8, 0x04, 0x92, 0x9c, 0x46, 0x71, 0x08,
  0xf9, 0xb4, 0xef, 0x40, 0xcb, 0x5f, 0x50, 0xa8, 0x0b, 0x28, 0x81, 0x17, 0x1d, 0xb7, 0xb7, 0xd9,
  0x43, 0x4e, 0x3c, 0xe4, 0x0d, 0x43, 0x38, 0x9d, 0x7a, 0x33, 0x39, 0x09, 0x9f, 0x4e, 0x6d, 0x6f,
  0xc3, 0x6f, 0xfe, 0x94, 0xd2, 0x29, 0xef, 0xca, 0x37, 0x9a, 0x3e, 0x03, 0x2f, 0x0c, 0xc5, 0x55,
  0x35, 0xb1, 0x94, 0x1f, 0xc5, 0x6e, 0x73, 0xed, 0x48, 0x3b, 0x49, 0xa2, 0xdf, 0xb4, 0x2d, 0xb7,
  0x09, 0xac, 0x04, 0x98, 0xb6, 0x2f, 0xd5, 0xb7, 0x1a, 0x30, 0x70, 0xa8, 0x68, 0x68, 0x62, 0x4e,
  0x20, 0x3d, 0x22, 0x59, 0x35, 0xbc, 0x73, 0x35, 0xde, 0x3a, 0x2d, 0x03, 0xb4, 0x2f, 0x2f, 0x4a,
  0x3d, 0xdb, 0xa8, 0x9d, 0xc0, 0x85, 0xa9, 0x67, 0xc5, 0xd2, 0x54, 0xd4, 0x5a, 0x2d, 0x7e, 0x5c,
  0xc5, 0xa8, 0x34, 0xfe, 0x3c, 0xd6, 0xdd, 0xdc, 0xde, 0x36, 0x8d, 0xa5, 0xea, 0x41, 0x49, 0xb4,
  0x0d, 0x7e, 0x9b, 0x57, 0x84, 0x5c, 0x7e, 0xab, 0x53, 0x6d, 0x1a, 0x09, 0xf8, 0x2a, 0xa8, 0x67,
  0x74, 0x86, 0xec, 0x53, 0x73, 0x13, 0xa5, 0xd5, 0x19, 0x92, 0x53, 0x03, 0x15, 0xd6, 0xbb, 0xdd,
  0x0e, 0x46, 0x43, 0xa2, 0x0a, 0xf8, 0x03, 0x4d, 0x65, 0x50, 0xfa, 0x74, 0x7c, 0x06, 0xc4, 0x7c,
  0x82, 0x95, 0x45, 0x84, 0xa0, 0x47, 0x9f, 0x2e, 0xd1, 0xda, 0x50, 0x13, 0xbf, 0xc8, 0xde, 0xc7,
  0xb5, 0xbb, 0xd3, 0xca, 0x60, 0x10, 0xab, 0x6e, 0xec, 0x5e, 0x66, 0x69, 0x3b, 0xaf, 0x31, 0xbe,
  0xc2, 0x7f, 0x31, 0x64, 0x41, 0xfd, 0x8d, 0x8e, 0x40, 0x6e, 0x0a, 0xa7, 0xe4, 0x3b, 0xcc, 0xd3,
  0x9e, 0xdb, 0xcf, 0xd0, 0x43, 0x9d, 0x6a, 0xde, 0x23, 0x84, 0x7c, 0x44, 0x8e, 0xec, 0x1f, 0x26,
  0x47, 0x9c, 0x66, 0x77, 0x55, 0x77, 0xdf, 0x53, 0x16, 0xc4, 0x19, 0x74, 0xfa, 0x2d, 0xc7, 0xc6,
  0x1b, 0xdb, 0xec, 0x20, 0x9e, 0xfd, 0x86, 0x25, 0xe9, 0x59, 0x7d, 0xc7, 0x7e, 0x05, 0x74, 0x72,
  0xef, 0x65, 0x16, 0xd4, 0xe3, 0x96, 0x9b, 0x82, 0xdd, 0x30, 0x4e, 0x9a, 0xa7, 0x0c, 0x98, 0x51,
  0x26, 0x57, 0x89, 0x6a, 0xed, 0x78, 0xab, 0x87, 0x7b, 0x9d, 0x32, 0xb4, 0xea, 0x92, 0x74, 0x34,
  0x8b, 0x70, 0xb5, 0xdf, 0xef, 0x62, 0x7b, 0x5b, 0xe9, 0x7d, 0x51, 0x33, 0x3d, 0x1c, 0xd1, 0x43,
  0xa7, 0x93, 0x00, 0xb0, 0x18, 0x8e, 0x15, 0x9a, 0x95, 0x02, 0xbc, 0x86, 0xcb, 0x1c, 0xef, 0xba,
  0x56, 0xfb, 0xb5, 0x56, 0xc7, 0xc1, 0x82, 0xac, 0x8a, 0x14, 0x8d, 0x55, 0x7b, 0x11, 0xc3, 0xd7,
  0xce, 0xc8, 0x5f, 0xbc, 0xd8, 0xab, 0xa1, 0xe3, 0x50, 0x3e, 0x15, 0xa9, 0x41, 0x79, 0xb4, 0xbc,
  0xa5, 0x54, 0xf2, 0x2a, 0xe5, 0x4e, 0x21, 0x28, 0x87, 0xda, 0x5e, 0x87, 0xf6, 0x8e, 0x77, 0x57,
  0xf9, 0x3a, 0x54, 0xc3, 0x7d, 0x65, 0x94, 0xb9, 0x44, 0x0c, 0xcd, 0x81, 0x39, 0x89, 0xfd, 0x82,
  0xe7, 0xd0, 0x76, 0xc1, 0xbb, 0xa4, 0xdd, 0x52, 0x5b, 0x82, 0x3e, 0xf6, 0xd0, 0x16, 0x9b, 0x13,
  0x34, 0x67, 0x46, 0xb7, 0x16, 0x58, 0x31, 0x1a, 0xe9, 0x52, 0x95, 0x70, 0x52, 0xfc, 0xe4, 0x8b,
  0xe7, 0xf7, 0x5e, 0xd6, 0x40, 0x26, 0x3b, 0x18, 0xbb, 0x4c, 0x38, 0xaa, 0x6a, 0xa8, 0xf9, 0xe4,
  0x45, 0x6a, 0x46, 0x42, 0x40, 0x45, 0xb6, 0x32, 0x78, 0x12, 0x18, 0xa2, 0x1d, 0xa5, 0x2f, 0x25,
  0xe6, 0xc8, 0x10, 0x0f, 0x13, 0xfa, 0x1d, 0x64, 0xb1, 0x8e, 0x15, 0x00, 0x56, 0xf7, 0x0e, 0x69,
  0x0d, 0xd0, 0x7d, 0xf5, 0xe5, 0x62, 0x15, 0x6a, 0xca, 0xda, 0x38, 0x87, 0xea, 0xd3, 0x51, 0x99,
  0x10, 0x98, 0x72, 0x5e, 0x09, 0x7a, 0x5c, 0xa3, 0x69, 0xe8, 0xc3, 0x7f, 0x25, 0x51, 0xc8, 0x1b,
  0x1c, 0x30, 0x5b, 0x0a, 0xb2, 0xe8, 0x77, 0x35, 0x64, 0xf1, 0x95, 0xf9, 0x25, 0x94, 0x9d, 0xd1,
  0x77, 0x5e, 0x0a, 0x51, 0xb2, 0x88, 0x78, 0x69, 0xda, 0x89, 0x7f, 0xcb, 0x57, 0x21, 0x40, 0x7e,
  0xdb, 0x8f, 0xc2, 0x07, 0x12, 0x92, 0xdb, 0x92, 0x5c, 0x2b, 0x18, 0x30, 0x5e, 0xd0, 0xdd, 0xfd,
  0x14, 0x1a, 0x27, 0x1b, 0x4b, 0x56, 0x10, 0x31, 0x75, 0xf9, 0xbe, 0x24, 0xdf, 0x86, 0x7b, 0x7e,
  0xc6, 0x44, 0x4a, 0x2c, 0xce, 0xb3, 0xa5, 0x7b, 0x69, 0x7e, 0xa5, 0xf0, 0xd2, 0x3b, 0xf2, 0x05,
  0x7a, 0x7f, 0x56, 0x09, 0xeb, 0xbb, 0x58, 0x8d, 0x5a, 0x60, 0x90, 0xd7, 0xe7, 0x9f, 0xd5, 0x02,
  0x27, 0x4c, 0xc2, 0xcf, 0x69, 0xfc, 0x4b, 0x4a, 0x32, 0x4b, 0xa2, 0x04, 0x93, 0xf9, 0xf9, 0xdd,
  0x32, 0xba, 0xd6, 0x79, 0x71, 0xf7, 0x83, 0xfd, 0xec, 0x24, 0xf9, 0x43, 0xac, 0xef, 0xad, 0x65,
  0x3a, 0x6a, 0x4f, 0xe4, 0x2c, 0xce, 0xe4, 0x11, 0x95, 0xb8, 0xb6, 0x44, 0xf9, 0xa5, 0x98, 0x03,
  0xdf, 0x32, 0x1a, 0xee, 0x43, 0x28, 0x86, 0xb7, 0x30, 0x95, 0xf5, 0x6b, 0x22, 0xb2, 0x15, 0xc9,
  0x34, 0x07, 0x24, 0x35, 0x37, 0xf1, 0x32, 0x85, 0x93, 0x0c, 0x78, 0xcb, 0xf4, 0xc1, 0x65, 0x79,
  0x3c, 0xb4, 0x32, 0x97, 0x79, 0xae, 0xc5, 0xf7, 0x25, 0x40, 0x4b, 0x2b, 0x0b, 0x76, 0x5b, 0x49,
  0xff, 0x1c, 0xb7, 0xf5, 0x1a, 0xcc, 0x01, 0xd9, 0x25, 0xa7, 0x80, 0x43, 0x76, 0x51, 0x8f, 0xf3,
  0x42, 0xff, 0x1b, 0xe0, 0xfd, 0x30, 0x66, 0xa1, 0x7c, 0x1c, 0xe6, 0xc9, 0xc2, 0x77, 0x58, 0xba,
  0x81, 0x09, 0xb1, 0x18, 0x49, 0x4b, 0x10, 0x89, 0xf1, 0xdd, 0x9e, 0x70, 0xb8, 0xd1, 0xa8, 0x17,
  0x4b, 0x66, 0xf4, 0xda, 0xbd, 0xc7, 0x70, 0x98, 0xb1, 0xf8, 0x30, 0x16, 0xe3, 0xcc, 0x24, 0x24,
  0x7e, 0x44, 0xbe, 0x0d, 0x2c, 0x37, 0x8c, 0x92, 0xf2, 0xf7, 0x36, 0x8a, 0xa6, 0x4c, 0xc5, 0xf0,
  0x80, 0x74, 0x3f, 0x1e, 0x51, 0x0b, 0x6c, 0xe5, 0xb3, 0xf7, 0x92, 0x47, 0xc6, 0x2c, 0xd7, 0xc7,
  0x91, 0x2d, 0x4d, 0x8a, 0xb3, 0xf2, 0x2c, 0xe2, 0xd7, 0x33, 0x84, 0xb4, 0x6c, 0x91, 0xf7, 0x80,
  0xb3, 0x09, 0x0b, 0x8a, 0x38, 0x9b, 0x30, 0x09, 0x0f, 0x04, 0x83, 0xd0, 0x87, 0x63, 0xbe, 0x20,
  0x12, 0x52, 0x47, 0xcf, 0x28, 0x12, 0x8b, 0xe3, 0xc0, 0x8e, 0x84, 0x2b, 0xde, 0xbd, 0xb7, 0x3d,
  0x5a, 0xae, 0x94, 0xc9, 0xe7, 0xc3, 0xf8, 0x98, 0x2b, 0x71, 0x84, 0xac, 0x6a, 0xf9, 0xfc, 0xb3,
  0xc0, 0xc8, 0xf7, 0xa4, 0x45, 0x08, 0xcc, 0x9b, 0x32, 0x67, 0x70, 0x6e, 0x76, 0x57, 0x64, 0x52,
  0x7c, 0xa8, 0xf9, 0x99, 0x88, 0x28, 0x0d, 0xfb, 0x8d, 0x10, 0x8e, 0x11, 0xfe, 0xa5, 0x65, 0x59,
  0x74, 0x22, 0xfc, 0x23, 0x1f, 0x1e, 0x91, 0xae, 0xfd, 0x91, 0xec, 0xf1, 0xe6, 0x91, 0x05, 0x91,
  0x84, 0x9a, 0x62, 0xfc, 0xb3, 0x2d, 0xf0, 0xbd, 0x29, 0x1e, 0x60, 0x18, 0xbe, 0x88, 0x15, 0x33,
  0x3d, 0x12, 0x56, 0x9a, 0x74, 0xc1, 0xf8, 0xed, 0x9d, 0xf0, 0x82, 0x09, 0x1b, 0x8c, 0x3c, 0x56,
  0x69, 0xc1, 0x44, 0x3a, 0x02, 0x04, 0x94, 0xb1, 0x44, 0xfb, 0x16, 0x81, 0x05, 0x4a, 0xe8, 0xd7,
  0x78, 0xc6, 0x92, 0x5b, 0x6c, 0xff, 0x09, 0x79, 0xae, 0x3d, 0xcb, 0xa5, 0x25, 0xfd, 0x76, 0xdf,
  0x24, 0x33, 0x47, 0x3f, 0xab, 0x52, 0x34, 0x8f, 0xf3, 0x14, 0xe5, 0xc0, 0xac, 0x99, 0x1f, 0x8e,
  0xa0, 0x37, 0x94, 0xd4, 0x3c, 0x4b, 0xa1, 0x0a, 0x24, 0xcf, 0x5d, 0xda, 0xc4, 0x8b, 0x4f, 0x3f,
  0x1d, 0x16, 0x40, 0x54, 0x11, 0x15, 0xcf, 0x77, 0x6a, 0x40, 0x18, 0x56, 0x5c, 0x94, 0x3c, 0x4f,
  0x8b, 0xc4, 0x3e, 0x7e, 0xae, 0x25, 0xf6, 0xf9, 0x15, 0xba, 0xaa, 0x86, 0x09, 0x97, 0x28, 0xe4,
  0x2a, 0x95, 0x67, 0xef, 0xf4, 0x18, 0xb3, 0xbd, 0x35, 0x67, 0x4d, 0x1a, 0x5a, 0xb5, 0xe8, 0x47,
  0x52, 0xe5, 0xf7, 0xca, 0x84, 0xc5, 0x18, 0x0d, 0xc6, 0x0b, 0x89, 0x39, 0xcb, 0xc8, 0x28, 0x1c,
  0x36, 0x82, 0x87, 0x5c, 0xe8, 0x34, 0xba, 0xf5, 0x44, 0xb7, 0xe4, 0x43, 0x49, 0x72, 0xbc, 0xd4,
  0x50, 0x62, 0x85, 0x67, 0xfd, 0x05, 0xa5, 0x3c, 0x52, 0xbf, 0xf0, 0x72, 0x16, 0x9d, 0x0e, 0x69,
  0x59, 0x5c, 0x87, 0xf5, 0xb5, 0x0e, 0x66, 0xd0, 0x64, 0x1b, 0xe0, 0xe3, 0x0b, 0x2a, 0xb6, 0xe1,
  0xcc, 0x57, 0x74, 0xfa, 0x68, 0xaa, 0x0e, 0x3b, 0x18, 0xb6, 0xd9, 0x2a, 0xe4, 0xe3, 0x2c, 0xec,
  0xc1, 0xc5, 0x3b, 0x18, 0xe1, 0x9d, 0xa0, 0x4f, 0xe6, 0x1f, 0x18, 0x70, 0xb0, 0x39, 0xb8, 0x17,
  0x07, 0x9b, 0x52, 0xb4, 0x1f, 0x01, 0x13, 0x51, 0x04, 0xde, 0x4d, 0x77, 0xd6, 0x9c, 0x5e, 0x65,
  0x96, 0xfd, 0xa3, 0x31, 0x62, 0xf9, 0x69, 0x84, 0x82, 0x1d, 0x75, 0x76, 0xb2, 0x07, 0xd7, 0x28,
  0x35, 0xd1, 0xbd, 0x48, 0x12, 0x1b, 0x3e, 0x06, 0x9a, 0x8c, 0xbd, 0x95, 0x7c, 0x59, 0x4b, 0xc6,
  0xb2, 0x28, 0xc7, 0xcb, 0xe8, 0x36, 0x63, 0x89, 0xdf, 0xf6, 0xe4, 0x6d, 0x30, 0x6b, 0x4b, 0xf4,
  0xb8, 0xde, 0x93, 0x31, 0x3c, 0xba, 0xc9, 0x03, 0x5b, 0x3e, 0x5a, 0x0f, 0x23, 0xbb, 0xe3, 0x68,
  0xbc, 0x8a, 0xc5, 0x78, 0xda, 0xad, 0x71, 0x2e, 0x58, 0x78, 0xe2, 0xa2, 0x26, 0xe4, 0x8b, 0x3d,
  0xe8, 0xa2, 0x11, 0xf8, 0x16, 0x88, 0x78, 0xe0, 0x2f, 0x72, 0xef, 0x56, 0xaf, 0xac, 0xf0, 0x70,
  0x20, 0x23, 0xcd, 0x30, 0xe4, 0x4f, 0x7a, 0x7a, 0x9f, 0x7f, 0xae, 0xfa, 0x2c, 0x10, 0x2a, 0xc2,
  0xef, 0x6d, 0x8f, 0x08, 0x35, 0x89, 0xdf, 0x1e, 0x1d, 0xe5, 0x29, 0x40, 0x3a, 0x11, 0x70, 0x72,
  0x9f, 0x5d, 0x79, 0x43, 0x0a, 0x3e, 0x70, 0x46, 0x10, 0x2b, 0x29, 0x06, 0xc2, 0x9d, 0x88, 0xdc,
  0x63, 0x0f, 0x7f, 0x9c, 0xc0, 0x12, 0x70, 0x0d, 0x06, 0x7e, 0xfb, 0xa6, 0x6d, 0xb5, 0x33, 0x6e,
  0x6b, 0xdd, 0x26, 0x81, 0x09, 0xaf, 0x6a, 0x7a, 0xa7, 0xf9, 0x7d, 0x0c, 0xed, 0x05, 0x7b, 0x87,
  0x3c, 0xff, 0xaa, 0x46, 0x7a, 0xf4, 0x0e, 0xd9, 0xaf, 0x3d, 0xa9, 0x47, 0x95, 0x6b, 0x60, 0xea,
  0x77, 0x85, 0x3e, 0x89, 0x09, 0xea, 0xbf, 0x83, 0xc2, 0xdf, 0xca, 0x0e, 0x11, 0xee, 0x9b, 0x56,
  0xab, 0xb3, 0x62, 0xd5, 0xcf, 0x20, 0x15, 0xf7, 0xad, 0x5d, 0x28, 0xfe, 0xd4, 0xb3, 0xbc, 0x37,
  0x23, 0x74, 0xab, 0xa1, 0xef, 0x9e, 0x80, 0xa5, 0x40, 0x43, 0x1d, 0x9a, 0x83, 0xb1, 0xe0, 0x89,
  0x1a, 0x86, 0xb2, 0x52, 0x8c, 0xc2, 0xde, 0xeb, 0x90, 0xd9, 0xa9, 0x69, 0x39, 0xd8, 0x2d, 0xd9,
  0x7a, 0xfa, 0xee, 0x1b, 0x7d, 0xbb, 0x06, 0x58, 0xb2, 0x14, 0xb6, 0xe3, 0x40, 0x7d, 0xc9, 0x64,
  0x4b, 0xed, 0xc1, 0x6f, 0xd5, 0x58, 0xeb, 0xbf, 0x4d, 0x34, 0xd3, 0xfa, 0x4d, 0x1e, 0x97, 0x4d,
  0xb5, 0xec, 0x67, 0x8c, 0xa5, 0xd6, 0xaf, 0x83, 0xa3, 0x7d, 0xa5, 0xd3, 0xe8, 0x42, 0x1d, 0x3e,
  0x76, 0xc5, 0x3d, 0xe2, 0xf4, 0x38, 0x1a, 0x26, 0xdf, 0x11, 0xa7, 0x63, 0x1b, 0xba, 0x7b, 0xcb,
  0x67, 0xae, 0x24, 0x23, 0xc1, 0x88, 0x8f, 0xfc, 0x82, 0xb4, 0x10, 0x5e, 0x14, 0x6f, 0x0a, 0x79,
  0x74, 0xea, 0xe6, 0x25, 0xd2, 0x03, 0x81, 0xd1, 0x0b, 0xc2, 0x81, 0x4f, 0x39, 0xfa, 0xe7, 0x73,
  0x5a, 0x0e, 0x05, 0xc2, 0xcc, 0xe6, 0x0c, 0x58, 0xcb, 0xc0, 0xf1, 0x77, 0xd1, 0xd0, 0x87, 0x51,
  0x37, 0x1f, 0xbc, 0x56, 0xf8, 0xd4, 0xe7, 0xe6, 0x28, 0xf4, 0xa1, 0x85, 0x5c, 0xdb, 0xab, 0x21,
  0x7b, 0x15, 0xca, 0xd8, 0x43, 0x0e, 0x75, 0x13, 0x3b, 0x01, 0x27, 0x50, 0x93, 0x84, 0x24, 0x9f,
  0x7b, 0xf2, 0x9f, 0xad, 0x04, 0xaf, 0x12, 0x50, 0x46, 0xc3, 0x8f, 0xc8, 0x4b, 0xf0, 0x53, 0x2d,
  0xd5, 0x6e, 0x6d, 0xd8, 0xc6, 0x18, 0x0f, 0x5a, 0xc5, 0x7f, 0x84, 0x8e, 0xc8, 0x19, 0xda, 0x0c,
  0x27, 0xab, 0x27, 0x72, 0xc0, 0x62, 0x3d, 0x01, 0xb4, 0x43, 0x06, 0x38, 0xf8, 0x53, 0x06, 0x9b,
  0xff, 0xda, 0x39, 0x34, 0x51, 0x9b, 0x34, 0x04, 0x81, 0x52, 0x43, 0xf2, 0xfa, 0xfa, 0x23, 0x6b,
  0x11, 0xdf, 0x06, 0x00, 0x71, 0x76, 0xf7, 0xe2, 0x84, 0x03, 0x65, 0xb7, 0xdd, 0xb1, 0xb5, 0x3f,
  0xb0, 0xd6, 0x8e, 0x0e, 0xd6, 0xd1, 0x01, 0x63, 0x92, 0xca, 0xe2, 0xe4, 0xe2, 0xf1, 0x7f, 0xbc,
  0x07, 0xaa, 0x91, 0x87, 0x17, 0x8e, 0x37, 0x18, 0x93, 0x63, 0x45, 0xb8, 0x39, 0x9c, 0x8d, 0xc0,
  0xcc, 0x61, 0xf2, 0x55, 0x0b, 0x8d, 0x0e, 0xa4, 0xfc, 0xe3, 0xfc, 0x20, 0xbe, 0x4c, 0x98, 0x18,
  0x21, 0xca, 0xc5, 0x63, 0x2e, 0xe4, 0xd5, 0x57, 0x7a, 0x42, 0x17, 0x8f, 0xa8, 0x08, 0x17, 0x13,
  0x48, 0x9e, 0x25, 0xcf, 0x83, 0x95, 0x6e, 0x92, 0x8e, 0x3e, 0xd2, 0x64, 0x40, 0x55, 0x7d, 0x03,
  0x8c, 0xa0, 0xa7, 0xc7, 0x5e, 0x5d, 0xf0, 0xe7, 0xc7, 0x60, 0x5f, 0xe4, 0xcc, 0xf2, 0xdc, 0x47,
  0x7e, 0x53, 0x04, 0xc7, 0x08, 0xb2, 0xc0, 0xa4, 0x8c, 0xf5, 0xb4, 0xc0, 0x01, 0x19, 0x37, 0x3c,
  0xba, 0xc9, 0xae, 0x40, 0x09, 0x57, 0xc8, 0xc8, 0xeb, 0x47, 0x12, 0xc2, 0xb9, 0x32, 0xba, 0xf1,
  0xe3, 0xbc, 0x68, 0x24, 0x9b, 0x0c, 0x23, 0x9a, 0x83, 0x75, 0x6c, 0xe1, 0x85, 0x09, 0xeb, 0xc3,
  0x4a, 0x45, 0x20, 0xa9, 0x7f, 0x26, 0x19, 0x8b, 0x9d, 0x94, 0x9f, 0x24, 0x5b, 0x6b, 0x77, 0x07,
  0xc0, 0x0f, 0xcd, 0xe5, 0xd3, 0x89, 0x08, 0x47, 0xfe, 0x1b, 0x5e, 0x79, 0x6f, 0x70, 0x72, 0x44,
  0x11, 0xd1, 0x26, 0x9d, 0xad, 0xbe, 0xd1, 0xed, 0xd1, 0x79, 0x68, 0x71, 0x39, 0x81, 0xdf, 0x31,
  0xfe, 0x86, 0xad, 0x52, 0x85, 0xc4, 0x56, 0xc5, 0x19, 0xe8, 0x70, 0xdc, 0xbd, 0xa9, 0x7d, 0x8a,
  0x58, 0xad, 0x56, 0x11, 0x44, 0x80, 0xd8, 0xe0, 0x30, 0x11, 0xb0, 0xcf, 0xf4, 0x5b, 0xf5, 0x0a,
  0xfe, 0xc9, 0xe0, 0x96, 0xb6, 0x2d, 0x50, 0x9a, 0x61, 0xec, 0x83, 0xf5, 0x8e, 0x53, 0xee, 0xdb,
  0x3d, 0xdb, 0x72, 0x53, 0xd6, 0xc0, 0xed, 0x66, 0x1a, 0x2d, 0x37, 0xbd, 0xde, 0xea, 0x60, 0x20,
  0xfb, 0x5c, 0x09, 0xb8, 0x4d, 0x3a, 0xd7, 0xe8, 0x1b, 0x86, 0x27, 0xc9, 0xca, 0xac, 0x35, 0x28,
  0x1b, 0xc7, 0x92, 0x94, 0xf8, 0xac, 0xf6, 0x11, 0x24, 0xa5, 0x14, 0x95, 0xd5, 0x3e, 0xce, 0x6d,
  0x5a, 0x6c, 0x67, 0xac, 0x84, 0x1e, 0x9b, 0xe8, 0x9a, 0x5d, 0x07, 0x9c, 0x80, 0xc0, 0xd0, 0x55,
  0x39, 0x10, 0xeb, 0xbe, 0x18, 0x7d, 0x36, 0xfa, 0x1d, 0x79, 0x8f, 0x7d, 0xc5, 0xf6, 0x85, 0x80,
  0xa7, 0xbb, 0x0e, 0xdc, 0xd4, 0xdd, 0xde, 0xd6, 0x29, 0x34, 0xc9, 0xbe, 0x24, 0x49, 0xf7, 0xff,
  0xea, 0xd5, 0x49, 0xbc, 0xdc, 0x2f, 0x56, 0xab, 0x31, 0x70, 0x07, 0x7d, 0x1b, 0x23, 0xb9, 0xff,
  0x4f, 0x5f, 0xb0, 0x8f, 0x47, 0xef, 0x8e, 0xbe, 0xc2, 0x95, 0x62, 0xaa, 0xcb, 0xaf, 0xf8, 0xa2,
  0x7d, 0xe2, 0xaf, 0x15, 0xd2, 0xbb, 0xc3, 0xad, 0x3e, 0x11, 0x32, 0xbc, 0x91, 0x8c, 0xf1, 0x12,
  0x77, 0x2f, 0xa0, 0x03, 0x82, 0xf8, 0xfa, 0x72, 0xbf, 0xbb, 0x3e, 0xd4, 0x1e, 0x7f, 0xf1, 0x99,
  0x46, 0xce, 0x09, 0x98, 0x38, 0x86, 0xcc, 0xcc, 0x77, 0x50, 0xd9, 0x79, 0xc8, 0xa2, 0xdf, 0x2c,
  0xae, 0x79, 0x8d, 0x1d, 0x87, 0x61, 0x90, 0xcd, 0x60, 0x6d, 0x49, 0x4b, 0x91, 0x6d, 0x91, 0x3c,
  0x7f, 0xee, 0x90, 0xc3, 0xcd, 0x45, 0x61, 0xa3, 0x66, 0x91, 0xf8, 0xee, 0x1b, 0x40, 0xb1, 0xfe,
  0x47, 0x6f, 0xd0, 0x57, 0xb4, 0x1f, 0x9f, 0x8f, 0xae, 0x6a, 0xb4, 0x4f, 0x9f, 0x8d, 0xae, 0x67,
  0x23, 0x0d, 0x1d, 0x52, 0x64, 0x28, 0xff, 0xff, 0xbc, 0xec, 0x4b, 0xc4, 0x3d, 0x8f, 0xf7, 0xed,
  0x4e, 0x1d, 0x78, 0x47, 0x25, 0xb2, 0x94, 0x03, 0x8c, 0xb6, 0xea, 0x7a, 0xe1, 0xa2, 0x82, 0x85,
  0x50, 0x4d, 0xdd, 0xb0, 0xfb, 0xf5, 0x56, 0x8d, 0x22, 0xcb, 0x6a, 0x22, 0x34, 0x24, 0x5f, 0x88,
  0x60, 0x71, 0x8c, 0xcb, 0xb7, 0x54, 0x9d, 0x33, 0xb6, 0xbc, 0x3a, 0x7f, 0xba, 0x7e, 0xf5, 0xdf,
  0xb4, 0xd1, 0x97, 0x74, 0x4e, 0x72, 0x0f, 0x6d, 0xfd, 0x00, 0x47, 0x78, 0xfe, 0x0c, 0xd0, 0xf2,
  0x3e, 0xdd, 0xf9, 0x4f, 0x38, 0xae, 0xd1, 0x2b, 0xa2, 0x3b, 0xce, 0xde, 0x2a, 0x41, 0x13, 0x81,
  0xf0, 0x69, 0x85, 0x4e, 0xf3, 0x52, 0xa7, 0x8f, 0xdf, 0xfd, 0x94, 0x2c, 0xfd, 0x5f, 0x45, 0xf4,
  0xe5, 0xdd, 0x43, 0xbd, 0xcb, 0x0e, 0x78, 0x1e, 0x50, 0x4c, 0x48, 0xaf, 0x27, 0xee, 0x25, 0x9f,
  0xd4, 0x53, 0x26, 0x37, 0x3d, 0xed, 0x2e, 0x56, 0x73, 0x72, 0x87, 0x5f, 0xdc, 0x60, 0x6e, 0x84,
  0x64, 0xf1, 0xb8, 0x09, 0xb3, 0x65, 0xee, 0x73, 0x0f, 0xfd, 0x86, 0x85, 0x4a, 0x9c, 0xd4, 0x70,
  0x41, 0x99, 0xc3, 0x3f, 0x73, 0x0f, 0xcf, 0x87, 0x84, 0x5f, 0xdf, 0x90, 0x7f, 0x9c, 0x34, 0x0f,
  0x69, 0xa9, 0xf0, 0x1c, 0x8b, 0x23, 0x1f, 0xd9, 0xeb, 0xbf, 0x95, 0x93, 0x19, 0x49, 0x43, 0x90,
  0xe2, 0xaf, 0x06, 0x87, 0x20, 0x75, 0xcc, 0x5d, 0x22, 0xa5, 0x3d, 0xbb, 0x1c, 0x33, 0x86, 0x98,
  0xd3, 0x13, 0x69, 0x35, 0xe7, 0xd6, 0x8a, 0x8d, 0xf9, 0x70, 0x8f, 0x91, 0xa7, 0x18, 0x12, 0xb6,
  0x1c, 0x8c, 0x10, 0x14, 0xc9, 0x56, 0xc7, 0xc4, 0x42, 0x59, 0x1c, 0x9c, 0x28, 0x64, 0x9d, 0x97,
  0x8a, 0x0e, 0xda, 0xe0, 0x13, 0x15, 0x7a, 0xe0, 0x64, 0xf7, 0xd9, 0x70, 0xe9, 0x64, 0xe1, 0x83,
  0x64, 0x0f, 0xee, 0x4c, 0x75, 0x8d, 0xb6, 0xe0, 0x0a, 0x73, 0x0c, 0xb8, 0x23, 0x3c, 0x2c, 0xf8,
  0x79, 0x34, 0xd9, 0xf9, 0xd1, 0x4d, 0xcb, 0x4b, 0x68, 0x1d, 0x50, 0x91, 0xfc, 0xb3, 0x91, 0x49,
  0x25, 0xb1, 0x28, 0xbf, 0xee, 0xad, 0x7d, 0xf2, 0xa1, 0x64, 0x20, 0x88, 0xc6, 0x03, 0x16, 0x60,
  0x23, 0xce, 0x4c, 0x05, 0x80, 0xc2, 0xe0, 0x15, 0x93, 0xea, 0x90, 0x0f, 0x2b, 0x40, 0xcd, 0xee,
  0xbb, 0x14, 0xe7, 0xd2, 0x37, 0x47, 0x09, 0xc7, 0x36, 0xd9, 0x1e, 0xf5, 0xc3, 0xa8, 0x75, 0x66,
  0xbc, 0x5a, 0x57, 0x89, 0x8b, 0x38, 0x32, 0x91, 0x4b, 0x5e, 0x64, 0x08, 0x91, 0xf0, 0xa4, 0x84,
  0x7b, 0xbc, 0x1f, 0x33, 0x20, 0xd6, 0xb1, 0xb2, 0x66, 0xf5, 0xeb, 0x4e, 0xc4, 0xcd, 0x37, 0x39,
  0x4c, 0x1c, 0x96, 0x61, 0x51, 0x5b, 0xc4, 0x9b, 0xf6, 0x5a, 0x9b, 0x48, 0x3e, 0xee, 0x12, 0x03,
  0x9c, 0x1d, 0x64, 0x90, 0xf8, 0x2f, 0x8f, 0x76, 0x22, 0x15, 0xde, 0xb0, 0xda, 0x6c, 0x5a, 0x48,
  0xdb, 0x87, 0x0c, 0xf8, 0xf9, 0x27, 0xcc, 0x94, 0xa7, 0x2f, 0xf9, 0xa8, 0x21, 0x55, 0x8e, 0x00,
  0xf0, 0x62, 0x84, 0xcd, 0x94, 0x22, 0x38, 0xbf, 0x43, 0x67, 0x81, 0xf7, 0x30, 0x04, 0x3f, 0xa3,
  0x96, 0xf7, 0x77, 0x2f, 0x19, 0x72, 0xd8, 0x95, 0x89, 0xa7, 0xf4, 0x31, 0xa7, 0x1b, 0x5f, 0x0b,
  0x02, 0x95, 0x30, 0x1d, 0xd0, 0xd2, 0xa2, 0x66, 0xf3, 0xc2, 0x8f, 0x65, 0x2e, 0x5f, 0xb1, 0x98,
  0x7e, 0x09, 0x33, 0xc0, 0x00, 0x8a, 0x51, 0x53, 0x90, 0xec, 0x27, 0x4f, 0xd4, 0xf3, 0xaf, 0x22,
  0x83, 0x54, 0x27, 0x0c, 0x44, 0xcd, 0x3e, 0xb4, 0xcc, 0x5e, 0x50, 0x9a, 0x9c, 0xb2, 0x7e, 0xac,
  0xeb, 0x62, 0x98, 0x6a, 0x16, 0x17, 0x32, 0x50, 0x50, 0x97, 0x07, 0x3f, 0x85, 0x83, 0x9f, 0x92,
  0x07, 0x4f, 0xe1, 0x24, 0x9f, 0x68, 0x06, 0x37, 0x30, 0x68, 0x21, 0x1e, 0xb8, 0x25, 0x0c, 0xda,
  0xa1, 0x6b, 0xae, 0x88, 0x99, 0x20, 0x9c, 0x53, 0x4c, 0x20, 0x76, 0x36, 0x8d, 0x31, 0xb0, 0x1f,
  0x3e, 0x61, 0xbf, 0x74, 0x83, 0x20, 0xa1, 0x4f, 0x0a, 0xc0, 0x38, 0x1e, 0xe8, 0xf6, 0x08, 0xf4,
  0x42, 0x58, 0x8e, 0xee, 0x38, 0x68, 0x6c, 0x08, 0xfb, 0x42, 0x4f, 0x71, 0xf3, 0xfa, 0x54, 0x84,
  0x2f, 0xf4, 0x14, 0x17, 0x85, 0xa6, 0xca, 0x53, 0x5c, 0xa2, 0x98, 0x1a, 0xea, 0x4b, 0x01, 0x03,
  0x45, 0x24, 0x0c, 0xfa, 0x26, 0x8b, 0x27, 0x44, 0x65, 0x84, 0x3a, 0x8c, 0x8c, 0x92, 0x44, 0x93,
  0xac, 0xb6, 0x1b, 0xdd, 0x7b, 0x5c, 0xf0, 0x26, 0x1e, 0x10, 0x40, 0xe2, 0x97, 0x5e, 0x2e, 0x9e,
  0xb2, 0xca, 0x98, 0xa4, 0x3b, 0x95, 0x71, 0xfc, 0x8d, 0x61, 0x09, 0x50, 0x1a, 0xe0, 0xb8, 0xe8,
  0xbb, 0xce, 0xce, 0x8b, 0xd0, 0x01, 0xdf, 0x90, 0x2e, 0x0a, 0x9d, 0xb0, 0xfa, 0x9d, 0x64, 0xf7,
  0x78, 0x56, 0xc6, 0xf7, 0x8a, 0x17, 0x75, 0x64, 0xcf, 0xf8, 0xfd, 0x41, 0xec, 0xf1, 0xf9, 0xa2,
  0x28, 0x3e, 0x19, 0x67, 0xcc, 0x5b, 0x39, 0xff, 0xda, 0xff, 0xd8, 0x78, 0x00, 0xca, 0x79, 0x02,
  0xe3, 0x8c, 0x73, 0x61, 0xce, 0x98, 0x4f, 0x0c, 0x09, 0xc0, 0x2c, 0x45, 0x3c, 0xfa, 0x0e, 0x68,
  0x68, 0x2b, 0x30, 0x0f, 0x4d, 0x44, 0x7f, 0xd5, 0x3a, 0x8c, 0x40, 0x90, 0x9e, 0x26, 0xc5, 0x1b,
  0xbf, 0xc7, 0x24, 0x66, 0x0a, 0x9b, 0x8f, 0xb1, 0xf1, 0x67, 0x5f, 0x7a, 0x43, 0xf8, 0xac, 0x4f,
  0x12, 0x50, 0xff, 0x12, 0x73, 0xa8, 0xe1, 0xf9, 0x2f, 0x98, 0xdb, 0x03, 0xdb, 0xe6, 0xdd, 0xcb,
  0xd9, 0xe8, 0x8b, 0x6a, 0x1a, 0xd9, 0xbd, 0xd8, 0x1e, 0x6a, 0xb0, 0x89, 0x5a, 0xee, 0xcf, 0x77,
  0x89, 0x83, 0x31, 0xfa, 0xd4, 0xdb, 0xc0, 0xd7, 0x46, 0xdf, 0xf9, 0xcb, 0xfd, 0xc0, 0x8b, 0x86,
  0x46, 0x6e, 0x51, 0x44, 0x49, 0x58, 0xc0, 0x23, 0x5c, 0x44, 0xbc, 0xe4, 0xf4, 0x50, 0x3a, 0x66,
  0xe5, 0x71, 0xf6, 0x59, 0x1e, 0x44, 0x54, 0x9d, 0xb9, 0xbb, 0x1e, 0xf9, 0xfe, 0xc9, 0x81, 0x8d,
  0xc8, 0x49, 0x49, 0x0e, 0x62, 0xae, 0xb1, 0xeb, 0x3e, 0x24, 0x6c, 0x5c, 0x66, 0x61, 0xce, 0x77,
  0x3f, 0xf4, 0x7d, 0x0d, 0x6f, 0x52, 0x9c, 0x59, 0xbe, 0x97, 0x4c, 0xea, 0x7f, 0x80, 0x4d, 0x61,
  0x30, 0xa4, 0x77, 0x22, 0x24, 0x95, 0xbb, 0x69, 0x8d, 0xee, 0x66, 0x7f, 0xcf, 0xae, 0xf5, 0x50,
  0x1f, 0x9e, 0x6b, 0x14, 0x99, 0x06, 0x2e, 0xec, 0x5e, 0xca, 0x26, 0x89, 0xae, 0x91, 0x7b, 0x2a,
  0x34, 0x52, 0x35, 0xd8, 0xe0, 0x0e, 0x2d, 0xc8, 0x05, 0x6d, 0x0a, 0x28, 0x3c, 0x9f, 0x3f, 0xae,
  0x88, 0x9f, 0x80, 0x60, 0x4a, 0x71, 0x65, 0x84, 0xef, 0xf3, 0xcc, 0xfb, 0x53, 0x71, 0x3f, 0xbd,
  0x44, 0xdb, 0x70, 0x9f, 0x2e, 0x4f, 0xf8, 0x49, 0x6b, 0xb9, 0x5a, 0xbc, 0x99, 0x4c, 0x22, 0xe8,
  0xf6, 0xff, 0xa0, 0xa7, 0xd2, 0x09, 0xac, 0x64, 0xa8, 0x81, 0x0d, 0x59, 0x2c, 0x65, 0x3a, 0xed,
  0x0c, 0xc4, 0x57, 0xc6, 0x8b, 0x0f, 0x66, 0xc5, 0xa3, 0x27, 0xa2, 0xe4, 0xa2, 0x36, 0x1f, 0xbc,
  0x6f, 0xd3, 0x6b, 0x5a, 0xec, 0x7e, 0x00, 0x2f, 0xb2, 0x54, 0xd5, 0x0a, 0x78, 0x60, 0x4a, 0x09,
  0x2e, 0xae, 0x87, 0x94, 0x8d, 0x80, 0xa3, 0x1a, 0x0b, 0x9d, 0xa5, 0x48, 0xfd, 0x9e, 0x66, 0x88,
  0x47, 0x9a, 0x14, 0xeb, 0x18, 0xb3, 0x24, 0xdd, 0xa5, 0xdd, 0xe4, 0x27, 0xd7, 0x02, 0xae, 0xfc,
  0x50, 0xc6, 0x7e, 0xd0, 0x7f, 0x8d, 0x56, 0x27, 0x1e, 0xf5, 0x26, 0xf5, 0x4a, 0x90, 0x51, 0x34,
  0x17, 0x87, 0xa2, 0x0b, 0xd6, 0xfc, 0x18, 0x14, 0x8d, 0x09, 0x8b, 0x32, 0x59, 0x08, 0x21, 0x15,
  0x71, 0x6d, 0xb3, 0x6e, 0xce, 0x9b, 0x72, 0x64, 0x32, 0x0f, 0xba, 0x58, 0x30, 0x9f, 0x47, 0xb0,
  0x1a, 0xef, 0x29, 0x88, 0x92, 0x02, 0xa5, 0x94, 0xed, 0xcb, 0x70, 0x76, 0x5e, 0x63, 0xf8, 0x44,
  0x09, 0x35, 0x40, 0x2b, 0x34, 0xa2, 0xe3, 0x9b, 0x93, 0x47, 0xc3, 0x26, 0x9e, 0x9b, 0xad, 0xb8,
  0x1d, 0x5f, 0x1e, 0x88, 0x73, 0x33, 0xcb, 0x85, 0x43, 0x9f, 0xcb, 0x0e, 0x66, 0x68, 0x35, 0xf7,
  0x3d, 0xcc, 0xae, 0x52, 0x64, 0xb4, 0x1d, 0x71, 0xc7, 0x10, 0xb0, 0xf6, 0x36, 0x4c, 0xe7, 0x17,
  0xdf, 0xc1, 0x74, 0xd4, 0xc1, 0x84, 0x03, 0xad, 0x48, 0xc3, 0xea, 0x9e, 0x0b, 0x25, 0x0c, 0xa5,
  0x94, 0xe1, 0x4f, 0xae, 0xd1, 0x95, 0x26, 0xa1, 0xa9, 0x66, 0xec, 0xad, 0x73, 0xe1, 0x05, 0x1b,
  0x0a, 0xf3, 0xe2, 0x2d, 0xed, 0xe8, 0x33, 0x9a, 0xf9, 0x6d, 0x46, 0x7a, 0x84, 0x6f, 0x26, 0x5d,
  0x58, 0x0c, 0xec, 0xdd, 0x55, 0x69, 0x97, 0x50, 0xae, 0xf0, 0x20, 0x5c, 0x4e, 0x26, 0xfb, 0x0f,
  0x39, 0x46, 0x30, 0xca, 0x8b, 0x6b, 0x52, 0x20, 0x83, 0xc7, 0x17, 0xbe, 0x42, 0x6a, 0x5e, 0x50,
  0x5b, 0x48, 0xfd, 0x43, 0x81, 0x15, 0x36, 0x7c, 0x2a, 0x2e, 0x9c, 0xa8, 0x59, 0x4c, 0xbb, 0x08,
  0x1c, 0x95, 0xa9, 0x2f, 0x50, 0xa2, 0x07, 0xa1, 0x9c, 0x13, 0x51, 0x1d, 0x07, 0x01, 0x0c, 0xba,
  0x9e, 0x8f, 0xe8, 0xfa, 0xa1, 0x64, 0x13, 0xfa, 0x50, 0x93, 0x22, 0xe5, 0x05, 0xe3, 0xeb, 0x29,
  0x7d, 0x90, 0x77, 0x1c, 0x35, 0xce, 0xed, 0xb6, 0x3e, 0x5c, 0x7b, 0x8d, 0x1f, 0xd8, 0x22, 0x62,
  0x34, 0xcc, 0xee, 0x8b, 0x3c, 0xee, 0xe5, 0xc1, 0x2c, 0xc8, 0x9d, 0x33, 0x9e, 0x74, 0x7a, 0xa0,
  0x6f, 0xf8, 0x0e, 0x2f, 0x29, 0xa8, 0x64, 0x60, 0xcd, 0x2c, 0xf7, 0xfe, 0xc4, 0x88, 0x1b, 0xfc,
  0xf2, 0x65, 0xca, 0x08, 0x7a, 0xc0, 0xac, 0x4d, 0xd0, 0xbe, 0x1f, 0xac, 0x44, 0xf4, 0x00, 0xed,
  0xab, 0x79, 0x8d, 0xa0, 0x95, 0xc0, 0x1b, 0x4c, 0x29, 0x42, 0xb9, 0x8e, 0x96, 0x79, 0x76, 0xf9,
  0xb2, 0x9f, 0xfa, 0x88, 0xd8, 0x50, 0x24, 0xe7, 0x0a, 0x91, 0xc3, 0x28, 0xae, 0xf5, 0x07, 0xb2,
  0x90, 0x79, 0xf7, 0x4b, 0xd0, 0x74, 0x74, 0x65, 0xf7, 0xe2, 0x0f, 0x94, 0xf6, 0x0f, 0xaf, 0xc5,
  0xbf, 0xfd, 0x5a, 0xb7, 0x6e, 0xb3, 0x8b, 0x68, 0xec, 0x2e, 0xbd, 0x94, 0x6f, 0x94, 0x65, 0x8b,
  0xc1, 0xa4, 0x60, 0x58, 0xa0, 0x92, 0x64, 0xe2, 0x08, 0x25, 0xe0, 0xc2, 0xc6, 0xf9, 0x4b, 0x12,
  0xb5, 0xfd, 0x64, 0x3c, 0x03, 0xe7, 0x48, 0x7b, 0xa2, 0xe4, 0x92, 0x30, 0x0b, 0x2c, 0x6b, 0xe0,
  0x9f, 0x40, 0xb3, 0x54, 0x44, 0x0e, 0xd7, 0xbb, 0x8c, 0x11, 0x56, 0xca, 0xca, 0x37, 0xa5, 0xcf,
  0xf5, 0x31, 0x7d, 0xb2, 0x4c, 0x5d, 0xd4, 0xe5, 0x3a, 0x76, 0xb9, 0x1e, 0xea, 0x12, 0x4b, 0xc4,
  0xf4, 0xc8, 0x3f, 0xb1, 0x0e, 0x9f, 0x7f, 0xe2, 0x34, 0xd4, 0xff, 0x44, 0xb6, 0x36, 0x79, 0xe7,
  0xb8, 0x70, 0x41, 0xe2, 0x47, 0x7c, 0x5f, 0x14, 0xe0, 0x0b, 0x8b, 0x00, 0xd1, 0x65, 0x33, 0x66,
  0x35, 0x0c, 0xf6, 0x4f, 0x00, 0xf2, 0xf1, 0xde, 0x2e, 0x2d, 0x68, 0x08, 0xf4, 0xe5, 0xdc, 0xb7,
  0x5b, 0x6a, 0xf2, 0xdb, 0xa9, 0x75, 0xf4, 0x24, 0xa3, 0xec, 0x4e, 0x2c, 0x92, 0x9b, 0x46, 0xef,
  0xcb, 0x53, 0x69, 0xca, 0x32, 0x29, 0xe7, 0xc1, 0x3d, 0xd4, 0x05, 0x86, 0x70, 0xa4, 0xde, 0x72,
  0x31, 0x19, 0x6e, 0x20, 0x25, 0x9d, 0xf7, 0x2d, 0xe5, 0xb4, 0xbb, 0xae, 0x9c, 0xfb, 0xd6, 0xaf,
  0x85, 0x5f, 0xfc, 0xb9, 0xd7, 0xab, 0x9b, 0xad, 0x46, 0xeb, 0x30, 0xf4, 0xeb, 0xbf, 0x6b, 0x5b,
  0xac, 0x14, 0x5e, 0xbd, 0x5e, 0xc6, 0xb3, 0x51, 0xa8, 0xfa, 0xaa, 0xe5, 0xbe, 0x54, 0xf6, 0x9f,
  0xa5, 0xbc, 0xf7, 0x6d, 0x0c, 0x88, 0x1b, 0x2c, 0xdd, 0xed, 0xf8, 0xa5, 0xbb, 0x9d, 0x95, 0x44,
  0x44, 0x68, 0x75, 0xa0, 0x41, 0x40, 0x03, 0x50, 0x7e, 0x07, 0x76, 0x35, 0x05, 0xbd, 0xe3, 0x16,
  0x79, 0x9e, 0x33, 0x73, 0xc6, 0xb8, 0xda, 0x94, 0x31, 0x4e, 0xd4, 0xee, 0x76, 0x22, 0x6a, 0x9f,
  0xd4, 0x5f, 0xd2, 0xd3, 0xfa, 0x8a, 0xee, 0x43, 0x59, 0xca, 0x09, 0x65, 0xb5, 0x4f, 0xc8, 0xa0,
  0x5b, 0x13, 0xab, 0xa7, 0xcf, 0x38, 0x33, 0xba, 0x44, 0x72, 0x89, 0x1c, 0x6e, 0x45, 0x65, 0xd1,
  0x45, 0xb0, 0xc3, 0x65, 0x09, 0x64, 0xd0, 0x45, 0xcf, 0x79, 0xbd, 0xb2, 0xa6, 0x24, 0x08, 0x8b,
  0x2c, 0x2a, 0x0e, 0x86, 0x86, 0x11, 0xe9, 0x07, 0x37, 0x5b, 0x00, 0x21, 0xb4, 0xa3, 0xab, 0x50,
  0xcd, 0xdf, 0x6b, 0x11, 0x03, 0x90, 0x86, 0x4b, 0x2d, 0xd2, 0xc6, 0xc0, 0xa0, 0xb1, 0xc4, 0xde,
  0x72, 0xc2, 0x09, 0xb0, 0x60, 0x9b, 0x88, 0xfd, 0x30, 0xc8, 0x19, 0xf4, 0x00, 0x48, 0x6d, 0xaf,
  0xf3, 0xb7, 0x5e, 0x61, 0xdd, 0x0b, 0xc2, 0x1e, 0xbf, 0x84, 0x2d, 0xf7, 0x7c, 0x74, 0x9e, 0xc5,
  0xbf, 0x1b, 0xe4, 0x17, 0xcc, 0xa2, 0x86, 0xd1, 0x3b, 0x73, 0x26, 0xc5, 0xf0, 0xb4, 0x28, 0xaa,
  0x67, 0x5e, 0x8a, 0xea, 0xc9, 0x9e, 0xeb, 0xd2, 0x9b, 0x83, 0x54, 0x61, 0x2e, 0x47, 0x3f, 0xd6,
  0xe8, 0xaf, 0xcd, 0xaa, 0x69, 0xfa, 0x8c, 0xb7, 0xdf, 0x27, 0x71, 0x70, 0xa7, 0xf6, 0x36, 0xb8,
  0xf8, 0xd4, 0x74, 0x13, 0xc6, 0x75, 0x49, 0x9e, 0xea, 0x5c, 0x8d, 0x4d, 0x95, 0x4d, 0x86, 0x85,
  0x2e, 0xad, 0xd1, 0x5f, 0x9a, 0x7c, 0x71, 0x8e, 0x3e, 0x17, 0x16, 0xc4, 0xbc, 0xf3, 0x0b, 0x6b,
  0xf4, 0x79, 0xae, 0x21, 0xbd, 0x67, 0x2b, 0x54, 0xd0, 0x2b, 0x4f, 0x32, 0x25, 0x2f, 0x1d, 0x9d,
  0x0a, 0x56, 0x31, 0x3b, 0xbb, 0xf5, 0xac, 0xf0, 0x07, 0x1b, 0xfd, 0xe1, 0xf1, 0xc7, 0x6b, 0xdb,
  0x13, 0xb9, 0xe5, 0xf2, 0xec, 0x8e, 0x0b, 0x96, 0x67, 0x87, 0xdd, 0x3e, 0xbe, 0xc9, 0xc4, 0x30,
  0xe5, 0xd1, 0x37, 0x15, 0x2b, 0x88, 0x28, 0x86, 0x5e, 0xad, 0x18, 0xfc, 0x90, 0xd8, 0xa7, 0x8f,
  0xb1, 0x0d, 0x20, 0x9d, 0x0c, 0xbd, 0x0a, 0x36, 0xb0, 0xd6, 0x1e, 0xb3, 0xb2, 0x2f, 0x11, 0xab,
  0x23, 0xb7, 0x34, 0x2f, 0x07, 0x25, 0xd4, 0x32, 0xe0, 0x3f, 0x05, 0xfe, 0x02, 0x68, 0x31, 0xa3,
  0x63, 0x0e, 0x5f, 0x98, 0xa0, 0x44, 0x2d, 0x67, 0xf4, 0x34, 0xbe, 0xeb, 0x76, 0x26, 0xa5, 0xbf,
  0x08, 0x67, 0x04, 0x33, 0x11, 0xc0, 0x7e, 0xb8, 0x54, 0x38, 0x0c, 0x7f, 0x0f, 0x1d, 0x3a, 0x3c,
  0x61, 0x3f, 0x21, 0x22, 0x47, 0xc6, 0xf6, 0x68, 0x22, 0x47, 0x66, 0x80, 0x67, 0x45, 0xe4, 0x7a,
  0xa2, 0x1f, 0x99, 0xc8, 0x79, 0x9d, 0x07, 0x89, 0x1c, 0xdb, 0x17, 0xe0, 0x38, 0xd5, 0x63, 0x83,
  0xf5, 0x35, 0xbb, 0x1f, 0xb1, 0xbd, 0x5e, 0x83, 0xd2, 0xfe, 0x7a, 0xef, 0xbc, 0x0d, 0x7e, 0xd2,
  0x3c, 0xb8, 0x4f, 0x45, 0x32, 0xa5, 0x42, 0x9c, 0x7c, 0x5a, 0x7b, 0xa0, 0xa5, 0x0c, 0x68, 0x36,
  0x30, 0x09, 0xb8, 0x26, 0xd1, 0x2e, 0xdf, 0x47, 0x7d, 0xc2, 0xf9, 0x3c, 0x35, 0x95, 0x1d, 0xb3,
  0x3c, 0x3f, 0x10, 0x99, 0x4d, 0x9a, 0x54, 0x22, 0x9d, 0x0d, 0x01, 0xd7, 0xb3, 0xa0, 0xb3, 0x1e,
  0x84, 0xfd, 0xf9, 0xd1, 0xd9, 0x67, 0x80, 0x4d, 0x13, 0x90, 0x4b, 0xaa, 0xf4, 0x54, 0xe4, 0x32,
  0x12, 0xf2, 0xa5, 0xdd, 0xc5, 0xa0, 0x6e, 0xb4, 0xb7, 0xfe, 0xae, 0x8a, 0x7c, 0xaf, 0x8f, 0xc8,
  0x39, 0x0b, 0x0d, 0x27, 0xa0, 0xc0, 0x06, 0xac, 0x18, 0xc2, 0xc0, 0x3f, 0xba, 0xa3, 0xbd, 0xde,
  0xb3, 0x3b, 0x99, 0xd7, 0x6c, 0xd7, 0xee, 0xb2, 0x94, 0x9b, 0xdc, 0xc4, 0xfd, 0x0e, 0x5d, 0x06,
  0xfa, 0x1e, 0x94, 0x5d, 0x3c, 0x4b, 0xf0, 0x23, 0x62, 0x52, 0xcc, 0x2e, 0x3a, 0x4f, 0xca, 0xf2,
  0xbe, 0x3e, 0x1f, 0xfd, 0x5a, 0x13, 0x89, 0xb1, 0x29, 0x1a, 0x96, 0xe7, 0x66, 0xf2, 0x21, 0x06,
  0xee, 0xdc, 0xbd, 0x80, 0x75, 0x76, 0x46, 0xf7, 0x35, 0x61, 0xe0, 0x26, 0x73, 0xf6, 0x6d, 0x6d,
  0x4a, 0x4a, 0xf2, 0xfe, 0x35, 0x4b, 0x10, 0x70, 0x8b, 0xc5, 0xb8, 0xc1, 0x5b, 0xf0, 0x53, 0xfe,
  0xc9, 0x11, 0xc5, 0x2b, 0x78, 0x6f, 0x74, 0x3b, 0xbb, 0x4f, 0x32, 0x55, 0xc4, 0x2e, 0xba, 0xb7,
  0x9d, 0x14, 0xf0, 0x0e, 0x80, 0xf2, 0x25, 0x80, 0x03, 0xfe, 0xb8, 0x22, 0xe7, 0x5a, 0x6e, 0x75,
  0x7a, 0x13, 0x34, 0xc2, 0xb6, 0x10, 0x9a, 0xa0, 0x07, 0xa5, 0x81, 0xa4, 0x0c, 0xcf, 0x0a, 0xa2,
  0xf2, 0x4d, 0x47, 0x5b, 0xc9, 0x16, 0xda, 0x4a, 0x40, 0x77, 0xc3, 0x80, 0x7f, 0x75, 0x8a, 0x92,
  0x5a, 0xc1, 0x37, 0x6a, 0xbe, 0xdf, 0x2b, 0x5f, 0x33, 0x80, 0x0d, 0x26, 0x02, 0xfe, 0xd3, 0xf5,
  0x0f, 0x3e, 0x4a, 0xca, 0xe5, 0xcb, 0x4e, 0x7c, 0xb8, 0x9d, 0xe9, 0x52, 0x72, 0x32, 0xe7, 0x40,
  0x0c, 0x6f, 0x3c, 0x14, 0xa3, 0x31, 0x4f, 0x96, 0xcc, 0x39, 0x3c, 0x15, 0x16, 0x5d, 0x35, 0x34,
  0x17, 0x1c, 0xf2, 0xb2, 0x70, 0x24, 0x12, 0xcc, 0xf0, 0x58, 0x97, 0xce, 0xa2, 0xf4, 0xb1, 0xa9,
  0x8e, 0xa9, 0x54, 0x7c, 0x82, 0x63, 0x25, 0x14, 0xb8, 0xd4, 0x78, 0x8d, 0x0b, 0x08, 0xd1, 0xcd,
  0xdf, 0xe0, 0xf7, 0xa6, 0x11, 0x16, 0xc9, 0x7c, 0x18, 0x38, 0x0b, 0x8b, 0x38, 0x92, 0xd1, 0x52,
  0x14, 0x75, 0xe5, 0x7b, 0x2a, 0x88, 0xd1, 0xf3, 0x70, 0x60, 0xc6, 0x5e, 0x47, 0x76, 0x04, 0x75,
  0x6c, 0x7d, 0x7b, 0xbb, 0xe5, 0x1c, 0xb3, 0x8e, 0xb1, 0xd8, 0x43, 0x2f, 0xb7, 0xbb, 0x96, 0x9b,
  0x72, 0x0d, 0x23, 0x7e, 0x29, 0xf0, 0x2c, 0xe0, 0x1b, 0x3a, 0x83, 0x43, 0x13, 0x29, 0xbc, 0x7b,
  0x88, 0x87, 0x32, 0x98, 0x3f, 0x83, 0x8f, 0x4d, 0x18, 0xfd, 0x27, 0x1d, 0x8e, 0x4f, 0x00, 0x95,
  0x21, 0x78, 0x94, 0x1b, 0xf0, 0xc2, 0x40, 0xe4, 0xe0, 0x3a, 0x2e, 0xfc, 0x95, 0xee, 0xb8, 0xf0,
  0x74, 0xf7, 0x21, 0xc0, 0xfc, 0xf8, 0x06, 0x8b, 0xaa, 0xe0, 0xc1, 0xdf, 0x68, 0x87, 0x93, 0x2f,
  0xa9, 0x32, 0x50, 0x32, 0xf4, 0x4b, 0xd0, 0x52, 0x0a, 0x41, 0xba, 0xca, 0xe2, 0xf1, 0x2e, 0x68,
  0x9c, 0x3c, 0xdd, 0x32, 0xf8, 0x55, 0x76, 0x4e, 0x2a, 0xb8, 0x83, 0x6a, 0x88, 0x5c, 0x4c, 0xb1,
  0xc8, 0x2e, 0x37, 0xd9, 0x55, 0xf6, 0x8b, 0x64, 0x2f, 0xbd, 0xe8, 0xdf, 0xcc, 0x16, 0xc7, 0x1e,
  0x61, 0x0c, 0xf0, 0x2f, 0xb9, 0x45, 0x24, 0xea, 0x7c, 0x62, 0xe0, 0xde, 0x53, 0xd6, 0x6e, 0x72,
  0x38, 0xbb, 0x1f, 0x69, 0xfa, 0xbe, 0xba, 0xfb, 0x61, 0xc2, 0x4e, 0x46, 0xa8, 0xe7, 0xd6, 0x86,
  0xcf, 0xdd, 0x1d, 0x39, 0x03, 0xbd, 0x25, 0x6f, 0xf0, 0x18, 0x1e, 0x25, 0x4c, 0x1a, 0x12, 0x79,
  0x5b, 0x9b, 0xbc, 0xfa, 0x4a, 0x44, 0xf5, 0x3d, 0x51, 0x47, 0x9e, 0xdd, 0xe3, 0xec, 0x4b, 0xd5,
  0xd4, 0x7e, 0x86, 0x1e, 0x96, 0x31, 0x3d, 0x9d, 0xb2, 0x58, 0x38, 0xbe, 0x94, 0xb5, 0x54, 0x9d,
  0x2f, 0x99, 0xd3, 0xd3, 0xd6, 0x62, 0xb5, 0x64, 0x9a, 0x86, 0xa1, 0xd4, 0x59, 0xf1, 0xea, 0xac,
  0x61, 0x9d, 0x35, 0x5e, 0x67, 0x8d, 0xd7, 0x59, 0x93, 0xeb, 0x60, 0x1e, 0x02, 0xe8, 0x65, 0x7b,
  0x1b, 0xfe, 0xae, 0x84, 0x71, 0x2e, 0x4e, 0x92, 0x23, 0x19, 0xb6, 0x38, 0x4f, 0xe2, 0x99, 0xe9,
  0x0b, 0xba, 0xc5, 0x79, 0x59, 0xaa, 0xab, 0xfb, 0xe2, 0xde, 0xdc, 0x82, 0x54, 0xb9, 0xee, 0xff,
  0x9d, 0x6b, 0x68, 0x29, 0x53, 0x9c, 0x06, 0xc3, 0xe8, 0x32, 0x38, 0xb2, 0xc9, 0xf0, 0x36, 0x3c,
  0x54, 0xa1, 0xee, 0xac, 0x1c, 0x61, 0x03, 0x66, 0x7d, 0xe6, 0xfc, 0x9e, 0xd9, 0x50, 0xd9, 0xb0,
  0x0b, 0x05, 0x59, 0x18, 0x95, 0xe4, 0x09, 0x7b, 0x2c, 0x9b, 0x78, 0xa3, 0xdf, 0x5d, 0xc7, 0xc8,
  0x68, 0x56, 0xbb, 0x9d, 0x3a, 0x49, 0xa0, 0x2e, 0x18, 0x87, 0x63, 0xbb, 0x01, 0xb5, 0xc8, 0x9c,
  0x46, 0xba, 0xa2, 0xcf, 0x58, 0x12, 0xd6, 0x47, 0x30, 0x94, 0xf4, 0x98, 0x66, 0x72, 0xbc, 0x99,
  0xb5, 0xe4, 0x66, 0xa0, 0x95, 0x53, 0xfc, 0x75, 0xea, 0x64, 0xdf, 0x4a, 0xf7, 0xd7, 0x4e, 0xc9,
  0x78, 0xdc, 0xb7, 0xb8, 0xe6, 0x35, 0x3d, 0xdd, 0x5f, 0xf3, 0x94, 0x30, 0x71, 0xb5, 0x2d, 0x2c,
  0xec, 0x55, 0xad, 0x4a, 0x84, 0xb8, 0x57, 0x5d, 0x13, 0xaa, 0x46, 0x58, 0x92, 0x0e, 0x17, 0x17,
  0x76, 0xf8, 0x28, 0x8a, 0x20, 0xa9, 0x51, 0xf9, 0x08, 0xe5, 0x87, 0xe9, 0x49, 0x32, 0x44, 0x85,
  0xf6, 0x92, 0x43, 0xd4, 0x7c, 0x08, 0xba, 0xec, 0x88, 0x2d, 0x14, 0x4a, 0x0e, 0x3b, 0xd2, 0x20,
  0x67, 0xe1, 0x24, 0x78, 0x6f, 0xf8, 0x63, 0xe1, 0xa0, 0x51, 0x92, 0xc6, 0x68, 0x31, 0xf0, 0x49,
  0x80, 0xd5, 0xb0, 0x2e, 0x35, 0x29, 0x76, 0x3d, 0xb9, 0x9e, 0x14, 0x3f, 0x18, 0xa2, 0x91, 0x68,
  0xc6, 0x16, 0x5b, 0x54, 0xdd, 0xea, 0xd8, 0xae, 0x53, 0x3e, 0x79, 0x2a, 0x8d, 0x26, 0x84, 0xb2,
  0xae, 0xa7, 0xdb, 0x96, 0x5b, 0x36, 0xd3, 0xed, 0x6e, 0x07, 0xfe, 0x82, 0xfe, 0x63, 0xd7, 0x2c,
  0xc7, 0x3d, 0xee, 0x48, 0x3f, 0xe8, 0x1e, 0x77, 0x99, 0x68, 0x7f, 0x5a, 0x52, 0x09, 0x4c, 0xff,
  0xc7, 0x8a, 0xfc, 0x03, 0x9e, 0x7d, 0x33, 0x8d, 0x78, 0x46, 0x8b, 0x8b, 0xff, 0x7e, 0x45, 0x7a,
  0xef, 0x3d, 0xb3, 0xba, 0x43, 0xc9, 0xba, 0x0e, 0x14, 0xb7, 0x7e, 0x02, 0xc6, 0x7d, 0xdc, 0x5a,
  0x4b, 0x29, 0x46, 0x08, 0x9c, 0x0c, 0x1a, 0xed, 0xe3, 0x33, 0xae, 0xd4, 0x05, 0xfc, 0x7b, 0xf3,
  0xe6, 0x69, 0x19, 0x83, 0x16, 0xfb, 0xa0, 0xa1, 0x9e, 0x43, 0x6d, 0xd8, 0x2a, 0x57, 0xf7, 0x4d,
  0xb2, 0x3e, 0x70, 0x87, 0x51, 0xa1, 0x1e, 0x85, 0x03, 0x13, 0x32, 0x9d, 0x6a, 0x8a, 0xab, 0x62,
  0x52, 0x23, 0x2f, 0x19, 0x8a, 0x61, 0x3d, 0x37, 0x51, 0x8b, 0x2b, 0x49, 0x2d, 0xae, 0x44, 0xb7,
  0x88, 0x40, 0xd2, 0x74, 0xd7, 0xdb, 0x5e, 0x8a, 0x03, 0xa8, 0x83, 0xa0, 0xb2, 0xbd, 0x7d, 0x12,
  0x88, 0x8b, 0xa7, 0x18, 0x77, 0x24, 0xc5, 0xd8, 0xcf, 0x31, 0x00, 0xb0, 0xdd, 0xa9, 0xd2, 0x12,
  0x75, 0x3a, 0xb0, 0xbc, 0x76, 0x7d, 0xd5, 0x69, 0xd5, 0xa7, 0xa7, 0x03, 0x2f, 0x80, 0xf6, 0x74,
  0x3c, 0xaa, 0x80, 0x7d, 0xcd, 0xec, 0x2d, 0xf9, 0xde, 0xdf, 0x0f, 0x1c, 0xb7, 0xd5, 0x38, 0x9f,
  0xa9, 0x31, 0x4c, 0x2a, 0x53, 0xd4, 0x9a, 0xcc, 0x9a, 0xed, 0x6e, 0xda, 0x76, 0xc7, 0x3b, 0x9f,
  0xa7, 0x04, 0x7c, 0xe2, 0xfc, 0x5e, 0x9c, 0xcd, 0x07, 0xcf, 0xf7, 0xe3, 0x5c, 0x2b, 0x84, 0x5b,
  0x23, 0x9b, 0x92, 0x92, 0x64, 0x80, 0xab, 0xdc, 0xc3, 0x90, 0xd3, 0x36, 0x25, 0xb6, 0xe0, 0xe5,
  0x19, 0x6d, 0x83, 0xe2, 0x3e, 0x5f, 0x7a, 0x79, 0x5e, 0x47, 0xd7, 0x6d, 0x74, 0xfc, 0x67, 0xa5,
  0x70, 0x5d, 0x1c, 0xd7, 0x7a, 0xa5, 0xb7, 0xac, 0x6b, 0x29, 0x0c, 0x75, 0x40, 0x3f, 0x66, 0x74,
  0x83, 0x7b, 0xa8, 0xc6, 0x27, 0xd2, 0x08, 0xdd, 0x6f, 0x0d, 0xc6, 0x6a, 0x39, 0xb0, 0xb5, 0x9f,
  0x8f, 0xc4, 0x0b, 0x47, 0x84, 0x7e, 0x11, 0x35, 0x8c, 0x4f, 0x01, 0xdd, 0x0f, 0x75, 0x3f, 0x3a,
  0x11, 0xdf, 0x99, 0x63, 0xb6, 0x9b, 0xc2, 0x2f, 0x86, 0xae, 0x38, 0xf4, 0x47, 0xfa, 0xc0, 0x17,
  0xd6, 0xe6, 0xed, 0x49, 0x03, 0x13, 0xcd, 0xc7, 0x06, 0x26, 0x2a, 0x88, 0x5b, 0x4a, 0x09, 0x91,
  0x89, 0x58, 0xc0, 0x16, 0x79, 0x0d, 0x25, 0xe2, 0xcc, 0x39, 0xf9, 0x9c, 0x44, 0x90, 0xd7, 0xb2,
  0x7e, 0x98, 0xa1, 0xc0, 0x65, 0xd1, 0x50, 0x58, 0x26, 0x68, 0xba, 0xbb, 0x61, 0xfb, 0xf3, 0x8e,
  0x9a, 0x6b, 0xc1, 0x42, 0x8f, 0x9e, 0x48, 0x97, 0xbb, 0xbc, 0x99, 0x37, 0xe3, 0xe7, 0xca, 0x08,
  0xef, 0x5e, 0xe6, 0x2a, 0xa6, 0x9a, 0x5f, 0xc8, 0x15, 0xbd, 0x49, 0x4c, 0x72, 0x73, 0x62, 0x1c,
  0x25, 0x00, 0xe4, 0xc5, 0x93, 0x59, 0xc5, 0x9d, 0x1f, 0x91, 0x6e, 0x7b, 0x5b, 0x97, 0x60, 0x6a,
  0x2a, 0xf6, 0xca, 0x17, 0xc1, 0xf6, 0xd4, 0x12, 0xad, 0x7b, 0x2d, 0x8e, 0x03, 0x6b, 0x12, 0xf3,
  0x8d, 0xe0, 0x62, 0x6c, 0xc4, 0x7e, 0x4a, 0xaa, 0x7a, 0x56, 0x61, 0x2a, 0x4a, 0x7e, 0x95, 0xba,
  0x5b, 0xf5, 0xa2, 0xe2, 0xfa, 0xe5, 0x8e, 0x3b, 0x2f, 0xe6, 0x4c, 0xd3, 0x1c, 0x7f, 0xd2, 0x25,
  0x2a, 0x8c, 0x37, 0xdd, 0x36, 0xa4, 0x69, 0xd8, 0x92, 0x50, 0x58, 0x97, 0xde, 0x2c, 0x94, 0x35,
  0xe9, 0x97, 0xfc, 0x25, 0x2f, 0x49, 0x03, 0x8a, 0xe8, 0x81, 0x51, 0x4b, 0xd0, 0xd6, 0xfe, 0x6a,
  0xb7, 0x66, 0xb5, 0xed, 0x55, 0xb7, 0x0f, 0x00, 0x90, 0xd2, 0x07, 0x67, 0x85, 0x31, 0x90, 0x89,
  0x1e, 0x4f, 0x3d, 0x8d, 0x79, 0x0b, 0x46, 0xfe, 0xf2, 0x11, 0xf3, 0xe5, 0x3d, 0x4c, 0x46, 0xd9,
  0x25, 0x59, 0xb2, 0x30, 0xa5, 0x29, 0x49, 0x02, 0xfd, 0x9c, 0xfc, 0x26, 0x52, 0xca, 0xf2, 0xfd,
  0x43, 0x48, 0xc2, 0xe0, 0x19, 0x07, 0x68, 0x44, 0x96, 0xd4, 0xb3, 0x2d, 0x8d, 0x6e, 0x4e, 0x12,
  0xa6, 0x64, 0x1d, 0x41, 0x08, 0x7c, 0x98, 0x77, 0x40, 0xd1, 0xe6, 0xd8, 0xf9, 0x86, 0xac, 0xc9,
  0xe1, 0xa9, 0xd0, 0x24, 0xca, 0x98, 0x72, 0xb6, 0x6d, 0xa8, 0x87, 0x42, 0x13, 0xd6, 0xf7, 0x4f,
  0xb7, 0x27, 0xd4, 0xe5, 0xe4, 0x93, 0x3f, 0xae, 0x62, 0x31, 0x6d, 0x0c, 0x06, 0x6d, 0x08, 0x63,
  0x07, 0x0c, 0x00, 0x9e, 0xe1, 0xcd, 0x62, 0xe6, 0xa0, 0x49, 0x0f, 0x4b, 0xf4, 0x6f, 0xb7, 0xb3,
  0x98, 0xc9, 0x95, 0xd8, 0xd3, 0x12, 0x3c, 0x70, 0xc4, 0x78, 0x46, 0x7a, 0xd9, 0x13, 0xee, 0xc8,
  0x78, 0x85, 0x8c, 0xfb, 0x07, 0xfd, 0xf7, 0xe9, 0x64, 0x92, 0xea, 0xc4, 0x8c, 0x5d, 0xcb, 0x08,
  0x22, 0xe1, 0x53, 0xaf, 0x69, 0xdc, 0xf9, 0xe0, 0xc1, 0x17, 0xbc, 0xe6, 0x67, 0x58, 0x21, 0x21,
  0x90, 0x56, 0x7f, 0xac, 0x01, 0x30, 0x70, 0xac, 0x25, 0x7b, 0x6b, 0x85, 0xfc, 0x3f, 0x40, 0x19,
  0x0f, 0x9e, 0xee, 0xa3, 0x80, 0x5c, 0x85, 0x91, 0x56, 0xc2, 0xa7, 0x93, 0x55, 0x18, 0xa9, 0x74,
  0xeb, 0x90, 0x28, 0x47, 0xf8, 0xc4, 0x33, 0xba, 0xf2, 0x4a, 0xa0, 0x72, 0x58, 0x94, 0x0d, 0x3b,
  0x19, 0xc8, 0xea, 0xda, 0x9e, 0x15, 0x36, 0xe5, 0xb4, 0x2a, 0x38, 0xf1, 0x3d, 0x1d, 0x77, 0x7a,
  0xdd, 0x27, 0x68, 0x70, 0xcf, 0x4c, 0x87, 0xc3, 0x61, 0xb9, 0xc9, 0x7a, 0xdc, 0x8f, 0x4e, 0x93,
  0xf3, 0xe8, 0x23, 0xc8, 0x17, 0x28, 0xc1, 0xd8, 0x1b, 0x36, 0xcf, 0x71, 0x88, 0x1c, 0xd4, 0x41,
  0x19, 0x3b, 0x41, 0x1e, 0xd8, 0x44, 0x21, 0x5c, 0x90, 0xb5, 0x2c, 0x30, 0xa8, 0x75, 0x16, 0xd1,
  0x12, 0xeb, 0xf6, 0xf0, 0xbe, 0x4b, 0x52, 0xdd, 0x37, 0x2c, 0x32, 0x8a, 0x53, 0x5d, 0x61, 0x42,
  0xc2, 0x0e, 0x13, 0x52, 0x57, 0x82, 0x04, 0x12, 0xcd, 0xc6, 0x84, 0x83, 0xf2, 0xc7, 0x18, 0x74,
  0x74, 0xf4, 0x8d, 0xb8, 0x7a, 0xff, 0x80, 0x4c, 0xa6, 0xb7, 0xd0, 0x2c, 0x78, 0x9f, 0x5b, 0x38,
  0xbf, 0x45, 0x7b, 0xae, 0x64, 0xfe, 0xf1, 0xcf, 0x3d, 0x68, 0xea, 0x59, 0x97, 0xae, 0xe5, 0x57,
  0x26, 0x3b, 0x4d, 0xf0, 0x4d, 0xb3, 0x98, 0xd3, 0xf7, 0x3d, 0xe1, 0x35, 0x2f, 0x5c, 0xc3, 0xf7,
  0x3e, 0x0f, 0x85, 0x06, 0xc1, 0x96, 0x40, 0xc1, 0x65, 0xda, 0x04, 0x7d, 0xc6, 0xee, 0x60, 0xf4,
  0xb2, 0xb7, 0xde, 0x7c, 0xe5, 0x50, 0x77, 0xbd, 0xd7, 0xed, 0x60, 0x5a, 0x40, 0x5a, 0x2d, 0x20,
  0x3a, 0xb4, 0xd4, 0x91, 0x25, 0xf0, 0x8b, 0x31, 0x31, 0xf1, 0x99, 0xc4, 0x34, 0xfb, 0xf8, 0x8b,
  0x5f, 0x53, 0xe8, 0x66, 0x76, 0x9b, 0x70, 0x74, 0x77, 0xfc, 0x79, 0x71, 0x00, 0x4c, 0xa4, 0x8c,
  0x77, 0x93, 0x42, 0x47, 0x55, 0x0e, 0x05, 0xc7, 0xe8, 0xe3, 0xa1, 0xd7, 0x8f, 0x1d, 0x3b, 0x72,
  0xe8, 0xf8, 0x91, 0xc3, 0x32, 0x99, 0x7c, 0x02, 0xb8, 0xc1, 0x2b, 0x03, 0x7c, 0x36, 0x2c, 0xd7,
  0xd0, 0x35, 0xff, 0xb8, 0xc7, 0xdf, 0xd3, 0x87, 0x2c, 0x58, 0xb0, 0x3e, 0x83, 0x2b, 0x5e, 0xd9,
  0x5b, 0x7f, 0xc9, 0x94, 0x47, 0x75, 0x9c, 0x7d, 0xb2, 0x29, 0x7c, 0xa2, 0x4e, 0x21, 0x15, 0x31,
  0x81, 0x07, 0x14, 0x5e, 0x9c, 0x3b, 0x3b, 0xdf, 0x64, 0x4e, 0xdf, 0x8f, 0x44, 0xac, 0x66, 0x74,
  0x8a, 0x37, 0xf4, 0xa7, 0x9a, 0x96, 0xc4, 0x41, 0xe5, 0x30, 0x57, 0x8a, 0xbd, 0xa5, 0x12, 0x41,
  0xff, 0x9e, 0x33, 0xe0, 0xc5, 0x2d, 0x19, 0x9e, 0x20, 0x5c, 0xa7, 0x9b, 0x94, 0x98, 0xd6, 0x1c,
  0xd3, 0x3d, 0xf9, 0x2a, 0x90, 0x44, 0x13, 0x7d, 0xc5, 0xae, 0xa5, 0x58, 0x8b, 0xd8, 0x7b, 0xc4,
  0xcd, 0x56, 0xfd, 0x5c, 0x15, 0x1d, 0x58, 0xe3, 0x90, 0x0b, 0x27, 0xa9, 0x2c, 0x42, 0xe0, 0x88,
  0xa1, 0x66, 0x75, 0xa0, 0x79, 0x45, 0x24, 0x55, 0x8e, 0x60, 0xff, 0xf7, 0xc0, 0xee, 0x9f, 0x5f,
  0x25, 0x0b, 0x53, 0xb7, 0x9f, 0xd2, 0x4f, 0x0a, 0x9d, 0x73, 0xca, 0xaf, 0x39, 0x75, 0x4a, 0xb6,
  0xf4, 0xb7, 0x5b, 0x49, 0x22, 0x25, 0xd6, 0x62, 0x2a, 0x1c, 0xd6, 0x98, 0x94, 0xc6, 0xdd, 0xa0,
  0xa3, 0xa7, 0x07, 0xf2, 0x25, 0x35, 0x41, 0xe1, 0xb0, 0xbb, 0x80, 0xdf, 0x2c, 0xf7, 0x92, 0xa5,
  0x2f, 0x4a, 0xc2, 0x32, 0x59, 0xba, 0x82, 0x71, 0xa0, 0xcc, 0x10, 0x6f, 0x6e, 0x43, 0x43, 0x91,
  0x80, 0x8f, 0xc9, 0x4e, 0x8c, 0xae, 0xfe, 0x53, 0x60, 0xa4, 0xec, 0x0c, 0x4f, 0xa1, 0xfb, 0x5e,
  0xca, 0x64, 0x66, 0x87, 0xc2, 0xbf, 0x3c, 0x41, 0x27, 0x13, 0xa7, 0x04, 0xd8, 0x06, 0xc6, 0x3e,
  0xb9, 0x76, 0xab, 0xda, 0x8c, 0xa6, 0x96, 0xe8, 0x16, 0x06, 0x75, 0xef, 0xdd, 0x51, 0x63, 0x71,
  0xb4, 0xbf, 0x11, 0x41, 0x40, 0x25, 0x75, 0x36, 0x7a, 0x39, 0x99, 0xf3, 0xb1, 0x24, 0x20, 0x0b,
  0xf4, 0xa2, 0x6c, 0x39, 0x14, 0x70, 0xe1, 0x1d, 0xff, 0xa8, 0xda, 0x4f, 0x57, 0xe5, 0x67, 0xbe,
  0xf9, 0x9a, 0x5d, 0x35, 0xe4, 0xb1, 0xe9, 0x69, 0xd2, 0x4e, 0xb7, 0xef, 0xa6, 0x52, 0x56, 0x7a,
  0x0d, 0xe0, 0x73, 0x2d, 0xdb, 0x07, 0xb2, 0x96, 0xb1, 0xe8, 0x9f, 0x38, 0xdb, 0x1d, 0xd5, 0x12,
  0x36, 0xbb, 0x4e, 0xd0, 0x5e, 0xb7, 0x06, 0x2a, 0x50, 0xb5, 0x43, 0x0d, 0x2c, 0x55, 0x33, 0x98,
  0x5d, 0xf3, 0xf1, 0xb5, 0x77, 0x1e, 0x5f, 0xfb, 0xc5, 0xe3, 0x6b, 0xef, 0x3e, 0xbe, 0xf6, 0xbe,
  0x5e, 0xf6, 0x3e, 0x2d, 0xc8, 0x9f, 0x7e, 0x2e, 0x7d, 0x28, 0x79, 0x1f, 0x7e, 0x0e, 0xaf, 0xf1,
  0xf1, 0xe7, 0xf0, 0xf0, 0xdc, 0x4d, 0x7b, 0xc5, 0xa7, 0x37, 0xed, 0x45, 0x04, 0xa4, 0x2f, 0x89,
  0x28, 0xe3, 0x9f, 0x7c, 0x4b, 0x99, 0x2c, 0x1d, 0x32, 0xd7, 0x65, 0x91, 0x79, 0x84, 0xad, 0x71,
  0x41, 0x6b, 0x52, 0x1c, 0xf2, 0x4e, 0x71, 0x3e, 0x3a, 0x25, 0x98, 0xe2, 0x81, 0xad, 0xbf, 0x5a,
  0x7d, 0xfd, 0x18, 0x80, 0x0b, 0xda, 0x05, 0x60, 0xaa, 0x29, 0xd6, 0x83, 0x31, 0xac, 0x24, 0x35,
  0x81, 0x7c, 0x75, 0x0a, 0xcd, 0xaf, 0xb5, 0x01, 0x10, 0x0f, 0xd9, 0x46, 0xf7, 0xa3, 0xb0, 0xd0,
  0x3d, 0xfe, 0xec, 0x43, 0x94, 0xe2, 0xee, 0x52, 0x44, 0x1a, 0x42, 0xe1, 0xa0, 0x09, 0x2b, 0xd2,
  0x66, 0x15, 0xc0, 0x58, 0x84, 0x97, 0x4a, 0x02, 0x32, 0x45, 0x9f, 0x50, 0x3f, 0x63, 0x3a, 0x33,
  0x01, 0x15, 0xe1, 0xc6, 0xbd, 0x20, 0xe8, 0x4c, 0x2d, 0x85, 0x39, 0x14, 0xa2, 0x72, 0x88, 0x0c,
  0x2b, 0xe4, 0x63, 0xdc, 0x7c, 0x55, 0xce, 0x73, 0xbe, 0x53, 0x3b, 0xd6, 0xdd, 0x8c, 0x65, 0x3c,
  0x21, 0xce, 0x01, 0xe5, 0x3d, 0x3f, 0xb4, 0xf1, 0xb6, 0x0b, 0xc7, 0x8f, 0x4e, 0xac, 0xd4, 0xc8,
  0x57, 0x13, 0x2e, 0x99, 0x3f, 0xb9, 0x57, 0x0f, 0xb1, 0xa3, 0x68, 0xc7, 0x9e, 0xab, 0xbf, 0xd0,
  0xc2, 0x61, 0xe6, 0x79, 0xfa, 0x2f, 0x8f, 0x8d, 0x79, 0x7c, 0x09, 0x86, 0x2d, 0xec, 0x65, 0xfa,
  0xe4, 0x3e, 0xa8, 0xbe, 0xdb, 0xcd, 0x5e, 0x9d, 0x1c, 0xb4, 0xa4, 0x10, 0xf8, 0x30, 0xa5, 0x71,
  0xbe, 0x0f, 0xd1, 0x92, 0x1e, 0x09, 0xab, 0xe1, 0xdb, 0xd2, 0x09, 0x7e, 0x3d, 0x2d, 0xf7, 0xfc,
  0x0f, 0x38, 0xfa, 0xf1, 0x57, 0xb5, 0xe3, 0xfc, 0x82, 0x22, 0x27, 0xb0, 0xf2, 0xd6, 0xea, 0xcf,
  0x7e, 0x88, 0xd1, 0xa3, 0x2c, 0xf4, 0x31, 0x5d, 0x1f, 0x0e, 0x27, 0x94, 0x93, 0xaf, 0x11, 0xf3,
  0x1c, 0x10, 0xb8, 0x1f, 0xf7, 0x84, 0xf7, 0x13, 0x41, 0x5a, 0x68, 0xf4, 0xfb, 0x61, 0xf4, 0xff,
  0xeb, 0xad, 0x23, 0x6f, 0x81, 0x1a, 0x33, 0x3d, 0x4d, 0xbf, 0xc8, 0xee, 0xf3, 0x83, 0xec, 0x83,
  0x42, 0x5d, 0x98, 0xe9, 0x42, 0x19, 0x9f, 0x63, 0x03, 0x37, 0xe9, 0x76, 0x56, 0x41, 0xf0, 0xb4,
  0xce, 0xd8, 0x59, 0xc7, 0x76, 0x5f, 0x01, 0xfe, 0x4a, 0x78, 0xca, 0x90, 0xbb, 0xef, 0xda, 0x75,
  0x3d, 0x4d, 0xe6, 0xf5, 0x6c, 0x07, 0x49, 0x09, 0xa7, 0xc5, 0x3f, 0xef, 0x75, 0xdb, 0xed, 0x97,
  0x85, 0xd5, 0x19, 0xca, 0xe2, 0x64, 0xd2, 0x80, 0x9a, 0xf8, 0x5f, 0x3e, 0xad, 0x31, 0xc3, 0xd0,
  0x33, 0xf0, 0x10, 0x1a, 0x37, 0xed, 0x67, 0xef, 0x3d, 0x14, 0xa6, 0xa3, 0xe3, 0x26, 0x8b, 0x9f,
  0x1d, 0x22, 0xb2, 0x30, 0x3b, 0xfa, 0xb1, 0x54, 0x30, 0x8d, 0xe7, 0x38, 0x5f, 0xbc, 0xd5, 0xe6,
  0x1a, 0xd1, 0xd3, 0xfe, 0x8a, 0x44, 0x4f, 0x9c, 0xf8, 0xa5, 0xdd, 0x77, 0x84, 0x17, 0x97, 0xba,
  0xcd, 0x4c, 0xb5, 0x89, 0xda, 0x69, 0x25, 0xf1, 0xa6, 0x30, 0xd4, 0xc6, 0xf4, 0x36, 0x9e, 0xec,
  0x02, 0xbc, 0xd1, 0x6a, 0xcc, 0xe8, 0xbb, 0x17, 0x75, 0x76, 0xf9, 0xd2, 0xc5, 0x1b, 0x93, 0xdd,
  0x81, 0x2b, 0x41, 0x84, 0x4c, 0x97, 0x1d, 0x4f, 0x95, 0x8b, 0xa6, 0xca, 0x8e, 0x62, 0x44, 0xc5,
  0x28, 0x27, 0xfa, 0xea, 0xcf, 0x8e, 0x1d, 0x7a, 0xe5, 0xd8, 0x4f, 0xf5, 0xed, 0x6d, 0xfa, 0xf9,
  0xca, 0xe1, 0x57, 0x8f, 0xc8, 0xe6, 0x82, 0x89, 0xf6, 0x6e, 0x26, 0x27, 0x19, 0x12, 0x65, 0x21,
  0xdc, 0xd7, 0x72, 0x9f, 0xcb, 0x3e, 0xee, 0x7d, 0x67, 0xfc, 0x79, 0x87, 0x8c, 0xc7, 0x91, 0x10,
  0x41, 0xd1, 0x12, 0x94, 0x30, 0x1c, 0x11, 0x79, 0x32, 0x1f, 0x72, 0x61, 0xe3, 0xa1, 0x5e, 0x51,
  0x1b, 0xcc, 0x63, 0x8b, 0xf9, 0xb1, 0x4d, 0x62, 0x43, 0xd4, 0xc8, 0xf7, 0x4c, 0xe1, 0x41, 0x42,
  0xe3, 0xa7, 0xaa, 0x4c, 0x38, 0xdc, 0x12, 0xe6, 0x03, 0xb1, 0x3f, 0x92, 0x09, 0xc1, 0xd7, 0x3b,
  0x1a, 0x49, 0x32, 0x48, 0xf0, 0xe0, 0x4b, 0x99, 0x00, 0xd4, 0x34, 0x1a, 0xe3, 0x97, 0xa4, 0x1c,
  0x9a, 0xc0, 0xe4, 0xe3, 0x67, 0x56, 0xe5, 0x24, 0x7c, 0x0c, 0x09, 0x78, 0x71, 0x59, 0x4a, 0xfd,
  0x2b, 0xf4, 0x2c, 0x0c, 0x14, 0x25, 0x37, 0x63, 0x71, 0x67, 0x78, 0x48, 0x91, 0x28, 0x1e, 0xca,
  0x43, 0xd7, 0xbd, 0x83, 0xe6, 0x8d, 0x61, 0xbc, 0xf1, 0x05, 0xf4, 0xc8, 0x23, 0xab, 0x6f, 0x14,
  0xf2, 0x48, 0xf9, 0x1e, 0xb2, 0xe8, 0x18, 0xa4, 0xaa, 0x7a, 0xa9, 0x90, 0xa8, 0xc7, 0x8b, 0xd4,
  0x64, 0x2e, 0x93, 0xd7, 0xf8, 0x85, 0xfb, 0xbb, 0x5c, 0xfa, 0xf0, 0xf2, 0x29, 0x46, 0x65, 0xb9,
  0x40, 0x69, 0x24, 0xc3, 0xaf, 0xe0, 0x93, 0x1f, 0xe9, 0x05, 0x91, 0xff, 0xd8, 0x07, 0x59, 0x42,
  0xb3, 0xc5, 0x7c, 0xd1, 0xd8, 0x8a, 0x46, 0x48, 0xc0, 0x47, 0x44, 0x47, 0x0f, 0x1b, 0x05, 0x7e,
  0x88, 0xe5, 0x7d, 0xa6, 0xb8, 0xc7, 0xb6, 0xeb, 0xd9, 0xba, 0x9c, 0x4e, 0x8e, 0xc7, 0x43, 0x49,
  0xa9, 0x19, 0xa6, 0xf9, 0x31, 0x75, 0x40, 0x6a, 0x5f, 0x1d, 0x74, 0x26, 0x97, 0xda, 0x29, 0x8f,
  0xc8, 0x93, 0x0a, 0xed, 0xcf, 0x4c, 0x06, 0xc7, 0x34, 0x44, 0x9f, 0xc6, 0x40, 0x87, 0x9f, 0xf4,
  0x70, 0x56, 0x4e, 0x3a, 0x27, 0x24, 0xf3, 0x9f, 0xd7, 0xbb, 0xab, 0x7c, 0xd2, 0xcc, 0x87, 0x08,
  0x01, 0x77, 0x8f, 0x9b, 0xee, 0x27, 0x41, 0x9a, 0xf5, 0x33, 0x1e, 0xc1, 0x58, 0x87, 0x69, 0x2e,
  0x21, 0xc0, 0x3f, 0x91, 0xeb, 0x2c, 0x12, 0x6d, 0xed, 0x69, 0xb5, 0x79, 0x26, 0xae, 0x49, 0xd7,
  0x5c, 0xc9, 0xe4, 0xf2, 0xc4, 0x17, 0x1a, 0xe2, 0xa8, 0x0c, 0xdf, 0x96, 0x67, 0xb3, 0x90, 0x57,
  0x7f, 0x91, 0xb8, 0x68, 0x52, 0x0f, 0xdd, 0xce, 0xe1, 0x6e, 0xc7, 0x46, 0x36, 0x7a, 0xa4, 0xad,
  0x58, 0x4e, 0x89, 0x91, 0x0f, 0x3a, 0x4f, 0xaa, 0x5b, 0x51, 0x7b, 0xf8, 0x67, 0x82, 0xcb, 0x0d,
  0x6c, 0x0c, 0xc0, 0x33, 0xc6, 0x2b, 0x3d, 0x93, 0x35, 0x1b, 0xa6, 0xb1, 0xe3, 0x3a, 0xe1, 0x8a,
  0x89, 0x9c, 0xdd, 0x3a, 0x4e, 0x24, 0xf2, 0x02, 0x13, 0x91, 0x69, 0x90, 0x11, 0xfc, 0x87, 0xfe,
  0x4d, 0x23, 0x9e, 0x31, 0x1e, 0x71, 0x87, 0x5e, 0x5c, 0x14, 0x11, 0x8c, 0xee, 0x2a, 0x29, 0x86,
  0x78, 0x8c, 0x15, 0xa1, 0x88, 0x48, 0x62, 0x41, 0xcc, 0x0c, 0x51, 0xa5, 0xf9, 0x0d, 0xf5, 0x18,
  0xcb, 0x7d, 0xae, 0xc8, 0x81, 0x8e, 0xe8, 0x60, 0x0f, 0x09, 0x71, 0xd5, 0x0c, 0xa4, 0x1c, 0x07,
  0xd9, 0xad, 0x5f, 0x45, 0x25, 0x01, 0x0d, 0x3b, 0x1b, 0x56, 0x3b, 0x10, 0x88, 0x19, 0xc6, 0x30,
  0xc3, 0x24, 0xbe, 0x25, 0xa4, 0xf4, 0xb5, 0xb6, 0x6d, 0xf5, 0xbd, 0xa2, 0x54, 0x99, 0x05, 0x64,
  0x48, 0xd8, 0x89, 0x80, 0xf4, 0x1a, 0xbd, 0xf4, 0x8a, 0xd4, 0x38, 0xe8, 0xec, 0x51, 0x70, 0x1c,
  0x2f, 0x3c, 0x86, 0x3a, 0x83, 0x05, 0x88, 0x9a, 0x4b, 0x44, 0x83, 0x42, 0xb5, 0x8b, 0x9b, 0x23,
  0x0a, 0x1f, 0x5f, 0x04, 0x84, 0x0d, 0x0e, 0x07, 0xf2, 0x4b, 0x61, 0x7d, 0x0f, 0x08, 0xcc, 0x6d,
  0x90, 0x43, 0x10, 0x0d, 0x81, 0xbf, 0xa0, 0xd8, 0x94, 0x32, 0x38, 0xfb, 0x90, 0x47, 0xea, 0x0b,
  0x24, 0xf1, 0xab, 0x1c, 0x38, 0x16, 0x91, 0xab, 0x7b, 0x2b, 0xbe, 0xcf, 0x8f, 0xd2, 0x2b, 0xcb,
  0x13, 0xc0, 0xb7, 0x08, 0xc8, 0xd9, 0x29, 0xd3, 0x23, 0x04, 0x53, 0x4a, 0x3c, 0xcb, 0xa0, 0x17,
  0xa7, 0xc2, 0xe5, 0x8c, 0x3b, 0xb4, 0x93, 0x18, 0xeb, 0x0e, 0xe3, 0x35, 0x7f, 0x97, 0x0e, 0x1c,
  0x4d, 0x31, 0x60, 0xff, 0xe5, 0xe8, 0xb6, 0x10, 0xa4, 0xd2, 0x8a, 0xc3, 0x56, 0xd8, 0x12, 0x2e,
  0xf0, 0x8d, 0xab, 0xd2, 0xdb, 0xdb, 0x21, 0x17, 0x8a, 0xf8, 0x49, 0x33, 0x55, 0x25, 0x86, 0x3b,
  0xc9, 0xa0, 0xaf, 0x78, 0x66, 0x3c, 0xbb, 0x6d, 0xf4, 0x16, 0x75, 0xc2, 0xfd, 0x0c, 0x00, 0xe0,
  0x33, 0x41, 0x48, 0xf3, 0x2f, 0x08, 0xf9, 0x17, 0x84, 0x7c, 0x52, 0x84, 0x1c, 0xee, 0x79, 0x12,
  0xcc, 0xd8, 0xe4, 0x0d, 0x7e, 0x18, 0x6d, 0x0d, 0xe2, 0x91, 0x50, 0xc5, 0x7d, 0x42, 0x2f, 0x52,
  0x14, 0x0b, 0xab, 0x23, 0x24, 0x09, 0xa1, 0xab, 0x90, 0x35, 0xf1, 0x16, 0x45, 0xa0, 0x0b, 0x2b,
  0x4b, 0x74, 0xa7, 0x2f, 0xc8, 0x3f, 0x29, 0x6e, 0xe4, 0x7d, 0x52, 0xf5, 0xbe, 0xc7, 0x47, 0xce,
  0x7f, 0x71, 0x29, 0x68, 0xa5, 0xe8, 0x96, 0x1c, 0xdd, 0x94, 0xe3, 0x81, 0xbf, 0x9f, 0x1c, 0x8a,
  0x7f, 0x1c, 0x00, 0x27, 0x02, 0xeb, 0xc7, 0xf5, 0xce, 0x5d, 0x68, 0x3e, 0xf5, 0x74, 0x1b, 0x96,
  0x66, 0x9d, 0x2d, 0x24, 0xfc, 0x77, 0x4b, 0x5d, 0x61, 0x3e, 0x26, 0xee, 0x6a, 0xc3, 0xaf, 0x09,
  0xe2, 0x3d, 0xe5, 0x07, 0xa8, 0x14, 0x79, 0x64, 0x53, 0x85, 0x51, 0x75, 0x9f, 0x7f, 0xb8, 0xc1,
  0xf8, 0xc0, 0x66, 0x54, 0x82, 0x3e, 0xa6, 0x01, 0x8b, 0x05, 0x7a, 0x8d, 0x32, 0x12, 0x7a, 0xe2,
  0xb5, 0xd7, 0x7f, 0xfe, 0xca, 0xa1, 0xd7, 0x8f, 0xad, 0x56, 0xb7, 0xcc, 0xb2, 0xce, 0xb2, 0x25,
  0xeb, 0xe9, 0x5c, 0x19, 0x75, 0x8a, 0xdf, 0xe9, 0xe9, 0x3c, 0xbc, 0xfb, 0x97, 0xcb, 0x7a, 0xba,
  0x80, 0xdf, 0x2e, 0xd2, 0xb7, 0xb9, 0x22, 0x7d, 0xfc, 0x77, 0x78, 0x2a, 0x89, 0xa7, 0x22, 0xab,
  0xf0, 0x7b, 0x78, 0x2a, 0x78, 0x4f, 0xac, 0xdc, 0x1f, 0xf4, 0xf4, 0x7c, 0xce, 0x7b, 0x2a, 0x78,
  0x4f, 0xde, 0xd7, 0x05, 0xf8, 0xca, 0xd2, 0x0f, 0xc0, 0x73, 0x41, 0x7a, 0x2e, 0xfa, 0xcf, 0x25,
  0x53, 0xb4, 0x5a, 0xf2, 0xda, 0x2a, 0xd1, 0xd8, 0xde, 0x67, 0xdf, 0x59, 0x6b, 0x7f, 0x84, 0xa7,
  0x79, 0xf1, 0x74, 0xb0, 0xe8, 0x7f, 0x3f, 0x38, 0x2f, 0x3d, 0x1f, 0xf4, 0x9e, 0x87, 0x15, 0x69,
  0x15, 0x8e, 0xbd, 0xf2, 0xd3, 0xa3, 0xc7, 0xa5, 0xb5, 0xc0, 0xfc, 0xc9, 0x62, 0x25, 0x7e, 0x43,
  0x2b, 0x41, 0x0f, 0xf2, 0x55, 0x9b, 0xcd, 0xf5, 0x2e, 0xc6, 0x98, 0x4f, 0xd5, 0xd2, 0x5a, 0xb3,
  0x3b, 0xe8, 0xbf, 0xde, 0x38, 0x6c, 0x9d, 0x17, 0xb7, 0xe8, 0xbd, 0x17, 0x6c, 0xf3, 0x94, 0xac,
  0xea, 0x94, 0x8d, 0x02, 0x0f, 0x00, 0xcc, 0x4c, 0xbe, 0x40, 0x17, 0x56, 0x31, 0x4b, 0x33, 0x4a,
  0xa4, 0x65, 0x2d, 0x9f, 0x83, 0x77, 0xe8, 0xa2, 0x63, 0x66, 0x8a, 0xfe, 0x6d, 0x73, 0xe7, 0x18,
  0x86, 0x3f, 0x3c, 0x0a, 0x6d, 0x62, 0xea, 0x5f, 0xaf, 0xed, 0xa5, 0x6a, 0x3e, 0xb7, 0xbd, 0xed,
  0xfd, 0x5c, 0x9c, 0x97, 0x9c, 0x68, 0xbd, 0x0a, 0xd3, 0xd3, 0x5a, 0xaa, 0xc6, 0xee, 0x35, 0xe2,
  0x3f, 0x39, 0xf6, 0x4f, 0xde, 0x30, 0x44, 0x46, 0x86, 0xc0, 0xec, 0x4f, 0xd6, 0x4e, 0x6d, 0x6f,
  0x7b, 0x70, 0x41, 0xbf, 0x70, 0xea, 0x37, 0x08, 0xdc, 0xa5, 0x2a, 0xe1, 0xcf, 0x43, 0xf5, 0x16,
  0x92, 0x62, 0xd6, 0x92, 0x35, 0x24, 0x61, 0xb5, 0x9a, 0xf0, 0x36, 0xd2, 0x78, 0x0d, 0x53, 0x3d,
  0x57, 0x63, 0xee, 0x0f, 0x75, 0x3c, 0x42, 0x96, 0xbc, 0xe5, 0x43, 0x7a, 0x23, 0x47, 0xbf, 0x80,
  0x2d, 0x2f, 0x3e, 0x99, 0x69, 0xcc, 0xc5, 0xe2, 0x04, 0x5b, 0xcb, 0x94, 0x2f, 0x59, 0x21, 0xa5,
  0xff, 0x4f, 0x11, 0x92, 0xe0, 0x2a, 0xe6, 0x71, 0x46, 0xb2, 0xe6, 0xc4, 0xa6, 0x67, 0x60, 0x51,
  0x0b, 0x00, 0x56, 0x6e, 0x46, 0xe6, 0x5d, 0xc5, 0x2a, 0x1a, 0xf7, 0x12, 0x82, 0x77, 0x3e, 0x0d,
  0xa6, 0x3c, 0xbd, 0xac, 0x69, 0x91, 0x16, 0x9a, 0x7e, 0x71, 0x17, 0x10, 0xc9, 0x64, 0x4a, 0xbe,
  0x8f, 0x83, 0xce, 0x51, 0xd9, 0x03, 0x82, 0x5c, 0x8d, 0xfc, 0x3a, 0xc2, 0x17, 0xc2, 0x0d, 0x09,
  0x2b, 0xfb, 0xdd, 0x2c, 0xfa, 0xc7, 0x82, 0x14, 0x9a, 0xc5, 0x3c, 0xba, 0x8b, 0xa6, 0x11, 0xb0,
  0x1b, 0x4b, 0xfb, 0xd6, 0xaf, 0x72, 0xcb, 0xe1, 0x6b, 0x96, 0xdb, 0xcc, 0x36, 0xda, 0xdd, 0x6e,
  0x3f, 0xc5, 0xaa, 0xcd, 0xce, 0x9b, 0xb0, 0xd9, 0x3d, 0xab, 0x4e, 0xd6, 0xa1, 0x54, 0x3e, 0xad,
  0x9b, 0xba, 0x81, 0x29, 0x69, 0x66, 0x78, 0x0d, 0x56, 0xec, 0x05, 0x28, 0x16, 0x2c, 0x15, 0xd1,
  0x8f, 0x13, 0xd9, 0x0f, 0x30, 0x90, 0x09, 0xba, 0x81, 0x52, 0xe3, 0x7a, 0xe1, 0x6b, 0x15, 0x70,
  0xd1, 0x98, 0xf0, 0xfe, 0x94, 0x6d, 0xdb, 0xfa, 0x12, 0x05, 0xd8, 0x64, 0x0b, 0xc7, 0x52, 0x22,
  0xf9, 0x79, 0xaa, 0x2f, 0x1f, 0xd8, 0x72, 0xfa, 0x43, 0xe9, 0xc5, 0x7b, 0xf0, 0xc2, 0x19, 0x86,
  0xd2, 0x86, 0x0c, 0x8d, 0x09, 0x5c, 0xd8, 0x1a, 0x35, 0xa0, 0x05, 0x6a, 0x46, 0x0a, 0x3e, 0xf8,
  0xe5, 0xc8, 0xb1, 0x97, 0xbc, 0x9c, 0xc8, 0x58, 0x46, 0x74, 0x2a, 0x25, 0x06, 0x9a, 0xdc, 0x83,
  0x2f, 0xa2, 0x6b, 0x3d, 0xe4, 0x31, 0x17, 0x56, 0x6e, 0xb8, 0x38, 0xef, 0xc8, 0x77, 0x59, 0x5c,
  0xe5, 0x0e, 0xcb, 0x04, 0x96, 0x7d, 0x66, 0xcc, 0x25, 0xc1, 0xcb, 0x89, 0x31, 0x5a, 0x7b, 0x42,
  0xd7, 0xaf, 0x30, 0x15, 0x95, 0xef, 0x51, 0x74, 0x5f, 0x64, 0xb2, 0x41, 0x2e, 0x7b, 0x53, 0x87,
  0xd7, 0xf7, 0x28, 0x0e, 0xfd, 0x2d, 0x6d, 0x6b, 0xd0, 0x69, 0x9d, 0x5b, 0xb5, 0x81, 0xc2, 0x23,
  0xb1, 0x1a, 0x22, 0xce, 0x61, 0x1c, 0x69, 0x11, 0x35, 0x96, 0x62, 0x63, 0x4b, 0xc4, 0xfd, 0xae,
  0x34, 0x1d, 0x24, 0xcb, 0x2c, 0x0a, 0x34, 0x3d, 0x65, 0xd7, 0xad, 0x5e, 0x2a, 0xd5, 0xa4, 0x9b,
  0x80, 0x29, 0x6a, 0xb6, 0xac, 0xe1, 0x2c, 0xb5, 0x19, 0xad, 0xf5, 0x62, 0x61, 0xde, 0x34, 0x59,
  0x17, 0x65, 0xad, 0x39, 0x34, 0xe4, 0xa1, 0x7e, 0x82, 0x61, 0x4d, 0x48, 0x5c, 0x13, 0x91, 0x3a,
  0xf0, 0xcf, 0x3d, 0x0a, 0xea, 0x80, 0x74, 0xe9, 0x1b, 0x8a, 0xe0, 0x0a, 0x5d, 0xef, 0x5e, 0x66,
  0x41, 0x10, 0xae, 0xe0, 0xc3, 0x1d, 0x8d, 0xe5, 0x12, 0xa1, 0x40, 0xb3, 0x9e, 0x2f, 0xc5, 0xe8,
  0xbe, 0xf6, 0xd6, 0xf1, 0x43, 0x19, 0x20, 0x34, 0x14, 0xeb, 0x60, 0xf7, 0x12, 0x13, 0x8e, 0x45,
  0x5f, 0xf5, 0xec, 0xc0, 0xad, 0xbd, 0xde, 0x68, 0x00, 0x36, 0xc0, 0x94, 0x19, 0x6d, 0xe2, 0x45,
  0x31, 0x9a, 0x3b, 0x06, 0x5e, 0x40, 0x51, 0x83, 0x77, 0x7a, 0x59, 0x4b, 0x91, 0xd3, 0xd5, 0x23,
  0x12, 0x3e, 0xf9, 0x41, 0xb6, 0x96, 0x33, 0x4b, 0xa6, 0x29, 0x96, 0x09, 0x3a, 0x9b, 0x29, 0x18,
  0xde, 0x54, 0x7e, 0x8f, 0x36, 0x98, 0x4b, 0x5e, 0x9c, 0x85, 0xab, 0x3c, 0x20, 0x2e, 0xe5, 0x4e,
  0xfa, 0xd6, 0xcf, 0x68, 0x54, 0xd6, 0xb8, 0x67, 0xcc, 0x25, 0x1e, 0x02, 0xc6, 0x37, 0xda, 0xdf,
  0xa4, 0xe8, 0xe9, 0x18, 0xec, 0x85, 0x9d, 0xfd, 0xbf, 0xcf, 0xb2, 0x7b, 0x70, 0xfb, 0x3c, 0xc9,
  0x8f, 0xec, 0x85, 0x88, 0xb5, 0xba, 0x7b, 0x4d, 0xda, 0x11, 0x36, 0x3b, 0xe4, 0xa0, 0x81, 0x99,
  0x62, 0x58, 0x6e, 0x0e, 0x68, 0x3c, 0xd4, 0xa4, 0x75, 0xfe, 0x35, 0xab, 0x07, 0x25, 0x11, 0x20,
  0xe1, 0x49, 0xc8, 0x76, 0x6c, 0x27, 0x05, 0x5d, 0x6c, 0x2a, 0x07, 0x0c, 0x20, 0xc9, 0x73, 0x79,
  0x9c, 0x83, 0x03, 0xee, 0x16, 0xee, 0xb3, 0x96, 0x82, 0x75, 0x30, 0x28, 0x10, 0x0e, 0x3b, 0xad,
  0x78, 0x97, 0x0a, 0x51, 0xb0, 0x7c, 0x76, 0xae, 0xe0, 0xef, 0x82, 0x7f, 0xe9, 0x06, 0xa0, 0x17,
  0x87, 0x56, 0xd5, 0x9a, 0x59, 0x6a, 0x64, 0x86, 0x0f, 0xbf, 0x12, 0x2e, 0x77, 0x98, 0xc2, 0xda,
  0x4a, 0x64, 0xcf, 0xab, 0x3d, 0xab, 0x95, 0xe6, 0xe7, 0x10, 0x89, 0x68, 0x80, 0xe4, 0x90, 0xc7,
  0xd3, 0xb5, 0xdd, 0xa6, 0x15, 0xba, 0x8c, 0xc1, 0x90, 0x2f, 0xb1, 0x56, 0x48, 0x9d, 0x56, 0x1a,
  0xaf, 0xbb, 0x7c, 0x05, 0x08, 0x25, 0xd9, 0x38, 0x38, 0x52, 0xf2, 0xf6, 0x08, 0x17, 0x44, 0xce,
  0x0e, 0xda, 0x34, 0xd9, 0xec, 0x7d, 0x49, 0x13, 0x68, 0x88, 0x0d, 0x30, 0x54, 0x8c, 0x1a, 0xbd,
  0x6b, 0xcb, 0xfd, 0x78, 0x83, 0x7f, 0x51, 0x93, 0xfa, 0x7a, 0x44, 0xd0, 0x77, 0x8b, 0x3a, 0xfa,
  0x9e, 0xf3, 0x4b, 0x96, 0x6f, 0x0b, 0xd7, 0x11, 0x57, 0x58, 0x44, 0xd8, 0xbf, 0xc0, 0x0c, 0x7b,
  0xec, 0x8b, 0xa1, 0xf4, 0x77, 0xd6, 0x3e, 0x1f, 0xea, 0x09, 0x17, 0xef, 0x45, 0xb6, 0x4c, 0xa2,
  0x47, 0xa0, 0x1e, 0xaf, 0xac, 0xbe, 0xce, 0x49, 0x87, 0x91, 0x75, 0xda, 0xad, 0x9a, 0x9d, 0x32,
  0x41, 0xd5, 0x90, 0x4f, 0x21, 0xf7, 0x33, 0x18, 0xc9, 0x36, 0x2d, 0x27, 0x05, 0xed, 0x82, 0x38,
  0xc5, 0x5f, 0x00, 0x4c, 0xe1, 0x8b, 0xb4, 0xb6, 0x85, 0x94, 0x1e, 0x90, 0xdc, 0x4d, 0x6b, 0x40,
  0xb3, 0xfa, 0x2d, 0xdb, 0x29, 0x6b, 0x27, 0x4f, 0xf9, 0x24, 0x9c, 0x97, 0x3f, 0xc3, 0xca, 0x1b,
  0x59, 0x5e, 0x28, 0xdb, 0x1b, 0x38, 0x00, 0x5b, 0x86, 0xef, 0xfd, 0xe5, 0x93, 0x2d, 0x0e, 0x61,
  0xe1, 0x0c, 0x4e, 0xdf, 0x30, 0x37, 0x13, 0x16, 0x9c, 0x86, 0x99, 0x6e, 0xd1, 0x5b, 0xe6, 0x2e,
  0x51, 0x82, 0x8b, 0x14, 0x5f, 0xfa, 0x6b, 0x91, 0xcc, 0x4b, 0x4b, 0x25, 0x63, 0x0c, 0x03, 0x47,
  0x43, 0x42, 0x87, 0x4e, 0x77, 0xf3, 0x55, 0x1f, 0x20, 0x53, 0xbe, 0x3b, 0xc4, 0x2c, 0xad, 0x57,
  0x00, 0x36, 0xd5, 0x3a, 0x21, 0xe0, 0x94, 0x1b, 0xf3, 0xe0, 0x53, 0x66, 0x03, 0x5d, 0x58, 0x98,
  0xbf, 0x56, 0x77, 0x4a, 0x6e, 0x6c, 0x8f, 0x9b, 0xe5, 0x21, 0x34, 0xd2, 0xe2, 0x93, 0xa0, 0x54,
  0xf2, 0x65, 0xe7, 0xab, 0x9d, 0x32, 0x4e, 0xf1, 0xed, 0xc8, 0x36, 0x5a, 0x6d, 0xd7, 0xee, 0xa7,
  0x52, 0x27, 0xcf, 0x62, 0x24, 0x88, 0xb3, 0x4b, 0x55, 0x31, 0x12, 0x01, 0x44, 0x5e, 0xe3, 0x0b,
  0xf2, 0xa6, 0xfc, 0x81, 0x1d, 0x0d, 0x06, 0xe2, 0x02, 0x05, 0x13, 0x96, 0xa4, 0x08, 0x89, 0x15,
  0x12, 0x7a, 0x57, 0x5e, 0xe2, 0x46, 0xed, 0x38, 0x63, 0x16, 0xae, 0xc8, 0x12, 0x10, 0xed, 0xa4,
  0x8a, 0x13, 0xf1, 0x2f, 0x96, 0x9f, 0x44, 0x40, 0x23, 0x38, 0x4b, 0xf3, 0xf9, 0x0c, 0x4f, 0xa9,
  0xc7, 0x9e, 0x61, 0xf7, 0x59, 0xe4, 0x1f, 0x6c, 0xf7, 0x11, 0x0c, 0x78, 0x14, 0x9c, 0xef, 0x80,
  0x94, 0xa2, 0x89, 0xc0, 0x34, 0xcb, 0xa6, 0xf9, 0xf8, 0xdd, 0x8f, 0xf3, 0x05, 0xf8, 0x57, 0x28,
  0xd5, 0x1c, 0x2e, 0x65, 0x87, 0x5a, 0x8b, 0x88, 0x41, 0x66, 0x8d, 0xfe, 0x09, 0x04, 0x1b, 0x84,
  0x21, 0xc2, 0x76, 0x54, 0x71, 0x54, 0xd9, 0x30, 0x01, 0x20, 0x5e, 0x9c, 0xde, 0xda, 0xb4, 0xed,
  0xb3, 0x50, 0xb0, 0xac, 0x3b, 0x4d, 0x68, 0x56, 0x4f, 0xd3, 0x73, 0x07, 0xa4, 0x8a, 0x7e, 0xab,
  0xa6, 0xa7, 0xd7, 0x81, 0xcf, 0x37, 0xc5, 0xb7, 0x61, 0xa0, 0x7d, 0x4c, 0x82, 0xe5, 0x54, 0xc5,
  0xa8, 0x90, 0xad, 0xda, 0xd5, 0x25, 0x1b, 0xe5, 0x2a, 0x2b, 0x1b, 0x0c, 0x7c, 0xb8, 0xde, 0xea,
  0x1c, 0xaf, 0x12, 0xf0, 0xc1, 0x53, 0x0a, 0x76, 0x9f, 0x2a, 0x1b, 0x69, 0x6d, 0xdd, 0x3a, 0x27,
  0x3e, 0x58, 0xe7, 0xfc, 0x0f, 0x6a, 0x6d, 0x6b, 0xe3, 0xcc, 0xd1, 0xc1, 0x3a, 0x2b, 0x46, 0xee,
  0xa2, 0x29, 0xd1, 0x6b, 0xdf, 0xae, 0x0f, 0x00, 0x14, 0x52, 0x4e, 0xda, 0x86, 0xd5, 0x70, 0x66,
  0x78, 0xf7, 0xcd, 0xb4, 0x69, 0xcc, 0x8a, 0x32, 0x5c, 0xe4, 0x0e, 0x0c, 0xc8, 0x3a, 0x87, 0x99,
  0xbf, 0x95, 0xae, 0xa3, 0xa7, 0xb2, 0xc9, 0xa2, 0x3f, 0xfb, 0x5b, 0xb9, 0x3a, 0xe8, 0x90, 0xd4,
  0x8c, 0xc6, 0x19, 0x00, 0x0b, 0x00, 0x02, 0xcd, 0x6d, 0xb6, 0x1c, 0x5c, 0x6f, 0xbf, 0x10, 0xfc,
  0x00, 0x40, 0x6a, 0xf4, 0xbb, 0xeb, 0xdc, 0xf0, 0x55, 0x45, 0x2e, 0xcc, 0xf8, 0x90, 0x03, 0x18,
  0xd7, 0x6d, 0x70, 0x6a, 0xbf, 0xde, 0xaa, 0x77, 0x50, 0x47, 0xd4, 0x18, 0x19, 0x64, 0x3b, 0xaf,
  0x65, 0x34, 0x8f, 0x31, 0x1a, 0x7e, 0xa3, 0x8c, 0x6e, 0xfe, 0x0c, 0xfe, 0x2f, 0xf3, 0xda, 0x6b,
  0x99, 0xc3, 0x87, 0x79, 0x13, 0xb8, 0xc3, 0x9a, 0x23, 0x93, 0x75, 0x52, 0x2a, 0xfa, 0xaf, 0xb5,
  0x3a, 0xd5, 0x4c, 0x2e, 0x0d, 0x22, 0x39, 0x7b, 0xaa, 0x44, 0xe9, 0x27, 0xa1, 0x00, 0xef, 0xf0,
  0xe1, 0x4d, 0xa2, 0x2f, 0xb2, 0x06, 0x02, 0x4b, 0x85, 0xea, 0x07, 0x93, 0x9a, 0x41, 0x6d, 0xc5,
  0x91, 0x80, 0x62, 0xc3, 0x14, 0x83, 0xa5, 0xaa, 0xa9, 0x7a, 0x3c, 0xb0, 0x26, 0x8c, 0x2d, 0x36,
  0x04, 0xf6, 0x8b, 0x4a, 0x56, 0xf8, 0x58, 0xf8, 0x2b, 0x98, 0x5d, 0x65, 0xb8, 0x2f, 0x20, 0x96,
  0x0a, 0x75, 0x05, 0xc0, 0x14, 0x13, 0x6f, 0x60, 0x13, 0xd0, 0x81, 0xb6, 0xac, 0x85, 0xd5, 0x0a,
  0xfa, 0x38, 0x56, 0xad, 0xa0, 0x52, 0x51, 0x6a, 0x05, 0xa6, 0xe0, 0xd0, 0x55, 0xb0, 0xc0, 0x88,
  0x46, 0xd4, 0xad, 0x93, 0xd4, 0xad, 0x33, 0x51, 0xb7, 0xce, 0x1e, 0xba, 0x1d, 0xb0, 0x34, 0xce,
  0x48, 0xd5, 0x69, 0xe6, 0xdb, 0xdb, 0x34, 0x12, 0x03, 0xfa, 0x8f, 0x4d, 0xd4, 0x28, 0x67, 0x49,
  0x64, 0x97, 0x62, 0x94, 0xe4, 0x14, 0xf3, 0x5c, 0x9d, 0xc0, 0xe6, 0x96, 0xe9, 0x6c, 0x5a, 0x9f,
  0xa1, 0x1f, 0x18, 0x63, 0x00, 0x13, 0x4a, 0x3b, 0xe2, 0xc3, 0x7b, 0x78, 0xd9, 0x88, 0x7f, 0x10,
  0x59, 0xab, 0x95, 0x41, 0xca, 0x3e, 0xf1, 0x22, 0x57, 0x55, 0x13, 0x26, 0x04, 0x1a, 0x96, 0x9f,
  0xad, 0x22, 0x22, 0xa1, 0x84, 0x3e, 0x41, 0x24, 0x88, 0x64, 0xe7, 0xf9, 0x08, 0x6f, 0xfb, 0x88,
  0x1c, 0xf0, 0x93, 0x64, 0x54, 0x8f, 0x68, 0x29, 0x90, 0x5b, 0x1d, 0x63, 0x52, 0x50, 0xba, 0xfa,
  0xc5, 0x66, 0x41, 0x9d, 0x54, 0x99, 0x12, 0x60, 0x32, 0x7a, 0x0a, 0x2b, 0xd4, 0x2c, 0x30, 0x35,
  0x8d, 0x65, 0xde, 0x0e, 0xe7, 0xc6, 0x8d, 0x4b, 0x77, 0x12, 0xda, 0x2f, 0x6c, 0x15, 0x29, 0xe3,
  0xf0, 0xbf, 0x76, 0x1e, 0x5f, 0xf8, 0x3d, 0x3c, 0x03, 0x31, 0xc4, 0xf4, 0x9a, 0xbe, 0x02, 0x8a,
  0x59, 0xd4, 0x19, 0xf5, 0x1b, 0xbe, 0xa0, 0x51, 0x01, 0xa4, 0x5a, 0xb8, 0x6b, 0x1f, 0xff, 0x51,
  0x9f, 0xe1, 0x3f, 0x29, 0x24, 0xdb, 0xec, 0xee, 0xc5, 0xe8, 0x10, 0x1c, 0xe3, 0xf3, 0xde, 0x8f,
  0x4f, 0x0f, 0x9e, 0xcb, 0x8b, 0xc4, 0xe0, 0xa6, 0x94, 0x14, 0x1c, 0x13, 0xbf, 0xa0, 0x36, 0x98,
  0xa1, 0xb5, 0x15, 0xab, 0xda, 0xdd, 0xb0, 0xfb, 0x80, 0x27, 0x9b, 0xe5, 0x66, 0xab, 0x5e, 0xb7,
  0x3b, 0x3a, 0xea, 0xcd, 0x3e, 0x09, 0xcb, 0xe5, 0x29, 0x8f, 0x06, 0x19, 0x68, 0xae, 0xf1, 0x98,
  0x94, 0x5a, 0x5e, 0xd1, 0xdd, 0xca, 0x1a, 0x2a, 0x61, 0x26, 0xba, 0x6f, 0xce, 0xc1, 0x7f, 0xf3,
  0xf0, 0x5f, 0x29, 0x0d, 0x42, 0x06, 0xfc, 0x07, 0xef, 0x72, 0xf0, 0x2e, 0x07, 0xef, 0x72, 0xf0,
  0x2e, 0x0f, 0xef, 0xf2, 0x79, 0x89, 0xc9, 0xa2, 0x37, 0x3f, 0x5d, 0x7b, 0x21, 0xc6, 0xea, 0x33,
  0x5a, 0x2f, 0x3b, 0xd1, 0x25, 0xa9, 0x27, 0x64, 0xbb, 0x13, 0x08, 0x60, 0x0a, 0xa2, 0x82, 0x00,
  0x84, 0xc6, 0x3c, 0x62, 0xa6, 0xaa, 0x38, 0x95, 0x8a, 0x17, 0xc7, 0x0c, 0xed, 0x05, 0x2e, 0x2b,
  0xcd, 0x6a, 0xa8, 0x61, 0x06, 0x58, 0x51, 0xcb, 0x39, 0x8e, 0x02, 0x0e, 0xe2, 0x3e, 0x11, 0xf8,
  0x6a, 0xd5, 0x93, 0xbd, 0xbc, 0x92, 0x0d, 0xd4, 0x26, 0x50, 0x06, 0x69, 0x56, 0xcd, 0x4a, 0xb3,
  0xb9, 0x98, 0x9f, 0x83, 0xbf, 0x33, 0x98, 0x78, 0x37, 0x40, 0xbd, 0x91, 0x84, 0x08, 0x3e, 0x46,
  0x54, 0x1b, 0x18, 0x99, 0x32, 0x4a, 0x5b, 0x55, 0x63, 0xbc, 0xb1, 0x19, 0x62, 0x70, 0xd0, 0x7f,
  0xb3, 0xa9, 0xd2, 0xf3, 0xfd, 0xb6, 0x81, 0xcd, 0xbb, 0xad, 0x0e, 0xbb, 0x3e, 0x2b, 0x77, 0x88,
  0xaa, 0x18, 0xc5, 0x45, 0x15, 0x66, 0x1f, 0xa8, 0x1c, 0x6f, 0xbf, 0xe1, 0x75, 0xaa, 0x8c, 0xb7,
  0xfa, 0xef, 0xc5, 0x09, 0x8c, 0xc8, 0x97, 0xb2, 0xa3, 0x98, 0x6a, 0xcb, 0x61, 0xd9, 0x19, 0xfe,
  0xbf, 0xd9, 0xd4, 0x16, 0xab, 0xea, 0x8e, 0x2c, 0xc2, 0xcb, 0x99, 0x7c, 0xa0, 0xb7, 0x96, 0x73,
  0x68, 0xd0, 0xe7, 0x36, 0x5b, 0xb1, 0xd6, 0x68, 0x8c, 0x55, 0x6a, 0x2e, 0x55, 0xb1, 0x3d, 0x78,
  0x1d, 0xd1, 0x9e, 0xa1, 0x8e, 0xf3, 0x33, 0x06, 0x3c, 0xa8, 0x68, 0xab, 0x06, 0xe5, 0x18, 0x23,
  0x22, 0xd9, 0x0b, 0x59, 0xde, 0x2e, 0x96, 0xec, 0x0a, 0x6f, 0x4b, 0xa5, 0x58, 0xc8, 0x55, 0x52,
  0xda, 0xbd, 0x1c, 0x60, 0x54, 0xde, 0x08, 0x0d, 0xff, 0x0d, 0xcb, 0x71, 0x23, 0xc6, 0x0f, 0xe3,
  0x9d, 0x01, 0xd4, 0x09, 0xac, 0x41, 0x68, 0xb1, 0x6b, 0x76, 0xbb, 0xbd, 0x72, 0x86, 0xea, 0x8a,
  0x75, 0x58, 0xd6, 0x74, 0x7e, 0xdf, 0x06, 0xd3, 0x50, 0xa5, 0xa4, 0x1e, 0xe8, 0xcb, 0x7c, 0xce,
  0xcc, 0x59, 0x94, 0xa0, 0x4a, 0x84, 0xde, 0x8d, 0x6e, 0x94, 0xac, 0x6c, 0xc1, 0x86, 0xe5, 0xfc,
  0x51, 0x2c, 0x48, 0x23, 0x36, 0xe4, 0xbf, 0x75, 0xfb, 0x56, 0x07, 0x28, 0x14, 0xde, 0xb3, 0xd7,
  0x83, 0xad, 0x22, 0xf9, 0x59, 0x45, 0xda, 0x24, 0x37, 0x2a, 0x51, 0x56, 0x68, 0x3e, 0x2e, 0xf3,
  0x68, 0x03, 0xb4, 0x1e, 0x39, 0x69, 0xf1, 0x41, 0xd3, 0x94, 0x2f, 0x1c, 0x85, 0x66, 0x19, 0xd7,
  0x4e, 0xc1, 0x9a, 0xb7, 0x4a, 0x96, 0xd2, 0xd4, 0xbc, 0xda, 0x94, 0xfa, 0x7f, 0xe5, 0xf8, 0xa6,
  0xf8, 0xc5, 0xa4, 0x60, 0x53, 0xa1, 0xb5, 0xec, 0x62, 0x46, 0x72, 0xf7, 0x3c, 0xcd, 0x59, 0x1e,
  0xa2, 0x99, 0x9d, 0x2b, 0xb2, 0xc5, 0x93, 0x16, 0x2a, 0xe2, 0x7a, 0x9a, 0x74, 0x8b, 0xea, 0xc0,
  0x16, 0xdb, 0xed, 0x61, 0xe0, 0xba, 0x54, 0x51, 0x4a, 0x01, 0x45, 0x17, 0xa4, 0x30, 0x05, 0x18,
  0xbb, 0x69, 0xc5, 0xab, 0xd0, 0x8f, 0x61, 0x85, 0x8f, 0x05, 0xde, 0xf2, 0xa7, 0x61, 0x2c, 0x77,
  0x95, 0xa6, 0x5d, 0x2c, 0xc9, 0xe9, 0x9e, 0xbd, 0x9d, 0x93, 0x82, 0x3e, 0x4b, 0xab, 0x0f, 0x6f,
  0xf3, 0x56, 0xd1, 0x5a, 0xa0, 0xd0, 0xce, 0x3c, 0x61, 0xac, 0x41, 0x89, 0x34, 0x3d, 0x52, 0x32,
  0x54, 0x1a, 0x79, 0xfc, 0xe9, 0x05, 0x29, 0xfd, 0xe9, 0xf8, 0xd1, 0x78, 0x71, 0xad, 0xc4, 0xb9,
  0x50, 0x33, 0xbb, 0xd9, 0xaa, 0xa7, 0x81, 0x2e, 0x25, 0x37, 0x71, 0x60, 0xcb, 0x83, 0x3f, 0x36,
  0x9c, 0xac, 0x9f, 0x9b, 0x7d, 0x48, 0x3f, 0x81, 0x37, 0x4f, 0x3a, 0x88, 0xe0, 0x92, 0x48, 0xb3,
  0x5f, 0x80, 0xd9, 0xe7, 0x29, 0x2a, 0x17, 0x4f, 0x56, 0xc8, 0x7b, 0xeb, 0x75, 0x7b, 0xcb, 0xec,
  0x50, 0x6d, 0x86, 0x7e, 0xcc, 0xe8, 0x2f, 0xec, 0x69, 0xde, 0x09, 0x5d, 0xe6, 0xac, 0x39, 0x80,
  0x6b, 0xec, 0x12, 0x76, 0xa3, 0xd0, 0x58, 0xc0, 0x2e, 0x99, 0x70, 0xd1, 0xcc, 0x36, 0x87, 0x2f,
  0x4c, 0xdc, 0x43, 0x31, 0xb6, 0x07, 0x8c, 0xd5, 0x5d, 0xa4, 0x1e, 0xb8, 0x68, 0x23, 0x26, 0x35,
  0x64, 0x59, 0x6c, 0x23, 0x52, 0x6a, 0x9f, 0x0e, 0x1a, 0xa4, 0x05, 0x6c, 0x07, 0x13, 0x95, 0x4e,
  0x10, 0x2f, 0x2a, 0xc2, 0xe0, 0x3d, 0x36, 0x5c, 0x94, 0x97, 0x13, 0x0d, 0xe4, 0x98, 0xa9, 0x25,
  0xd9, 0xfb, 0x8e, 0x5d, 0x6f, 0xe7, 0x96, 0xdc, 0x24, 0xdb, 0x9a, 0x74, 0x29, 0x2e, 0xc2, 0xad,
  0x60, 0x82, 0x73, 0xb2, 0xe7, 0x71, 0x61, 0x44, 0x9c, 0x35, 0x7f, 0xc4, 0xfc, 0xa0, 0x33, 0xf1,
  0xee, 0x76, 0x61, 0xf3, 0x08, 0xde, 0x24, 0x22, 0xd3, 0xd6, 0x1d, 0xad, 0xc8, 0xad, 0x24, 0x72,
  0xde, 0x46, 0xdf, 0x65, 0x81, 0x46, 0x84, 0xe7, 0xd7, 0x98, 0xfb, 0xb6, 0xbb, 0x99, 0x85, 0xb5,
  0x3c, 0x82, 0x41, 0x2d, 0xf0, 0xca, 0xb7, 0x0d, 0x5b, 0x90, 0xd2, 0xf1, 0xe8, 0x51, 0x4f, 0x07,
  0x32, 0x89, 0x49, 0x7e, 0x04, 0xc1, 0x14, 0x63, 0x49, 0xa7, 0x92, 0x5e, 0xd9, 0xbe, 0xf0, 0xc2,
  0xd1, 0xc4, 0x29, 0x65, 0x65, 0x18, 0x2c, 0xe3, 0x9f, 0x35, 0x6e, 0x58, 0x7d, 0xe4, 0x8d, 0xcc,
  0x5c, 0x16, 0x10, 0xcf, 0x2a, 0x52, 0x99, 0x16, 0xc6, 0xb1, 0x25, 0xae, 0x23, 0x8e, 0x2b, 0xd1,
  0xf6, 0x43, 0x87, 0x1f, 0x42, 0x52, 0xc0, 0x36, 0x32, 0x64, 0x16, 0x32, 0xb4, 0x25, 0x66, 0x5d,
  0x57, 0xac, 0x90, 0xbc, 0x89, 0xe0, 0xf9, 0x1b, 0xb6, 0x3e, 0xf9, 0x65, 0x47, 0x51, 0x63, 0x2f,
  0x9e, 0xd3, 0x7e, 0x9d, 0xfc, 0xe4, 0x07, 0xb3, 0x6c, 0xcc, 0x94, 0xf7, 0x4d, 0x1d, 0x6f, 0xd8,
  0x11, 0x58, 0x8b, 0x75, 0xc0, 0xde, 0x97, 0x78, 0xe7, 0x83, 0x39, 0xbb, 0x8d, 0x87, 0x41, 0xb9,
  0xa9, 0xa4, 0xbb, 0x91, 0x91, 0x20, 0xc0, 0xbc, 0x60, 0xc2, 0x20, 0xe0, 0xaa, 0x77, 0x52, 0xc6,
  0x78, 0xec, 0x3d, 0xd5, 0x15, 0xb4, 0xa4, 0xfb, 0x3d, 0xfc, 0x3a, 0x81, 0x6c, 0x1d, 0x09, 0x9d,
  0xe1, 0x45, 0xde, 0x05, 0xd6, 0x9e, 0xe4, 0x42, 0x41, 0xc0, 0xed, 0x2c, 0x62, 0x4f, 0xa4, 0x32,
  0x82, 0xe6, 0x7a, 0x64, 0x4b, 0x42, 0xc7, 0x67, 0x74, 0xc1, 0x21, 0xfa, 0x7e, 0x83, 0x5e, 0x19,
  0x06, 0x1d, 0x74, 0xa4, 0xae, 0xc5, 0x7d, 0x04, 0xad, 0xc8, 0x2f, 0x24, 0xa0, 0x85, 0xd7, 0x77,
  0x9e, 0x89, 0xbd, 0x81, 0x4a, 0xe7, 0x38, 0x8c, 0x38, 0xf3, 0xc3, 0x40, 0xe9, 0x92, 0xb4, 0x1a,
  0x9d, 0x4d, 0x8a, 0x1d, 0xd9, 0xaa, 0x9f, 0x9b, 0xd4, 0xe1, 0x9e, 0xa2, 0x50, 0xea, 0x33, 0x58,
  0xe3, 0x29, 0xee, 0x2b, 0xf8, 0xd9, 0xb6, 0x68, 0x0c, 0x52, 0x58, 0x0f, 0x68, 0xf7, 0x19, 0xc7,
  0xec, 0xff, 0xe4, 0x5b, 0x69, 0xc5, 0xb2, 0xba, 0x12, 0x38, 0x3e, 0x89, 0xc0, 0x48, 0xa1, 0x4c,
  0x2a, 0xfb, 0xc6, 0xc4, 0xc1, 0x89, 0x39, 0x0e, 0x0e, 0xc5, 0xb4, 0xd9, 0x3f, 0x36, 0xb4, 0xb1,
  0xe7, 0x32, 0x46, 0x5d, 0x1d, 0x7f, 0xf3, 0x67, 0xe8, 0x7e, 0x19, 0xdb, 0x0f, 0x23, 0x2e, 0x6a,
  0x47, 0x5c, 0xdf, 0x47, 0x4d, 0x11, 0x2f, 0xfd, 0x45, 0xdc, 0x61, 0xf2, 0x4c, 0x03, 0xe8, 0xe0,
  0xb5, 0x4a, 0x21, 0x9b, 0x34, 0x85, 0x8f, 0x7e, 0x9a, 0x1c, 0xb0, 0x2d, 0x9c, 0x7c, 0x72, 0xc2,
  0xcb, 0xae, 0x49, 0x91, 0xe0, 0x05, 0x2a, 0x86, 0x3c, 0xec, 0xa4, 0x48, 0x2e, 0xe9, 0x82, 0x38,
  0x81, 0x7f, 0xea, 0xab, 0xac, 0x51, 0x50, 0xc1, 0xc4, 0x86, 0xc5, 0x59, 0xa7, 0xd6, 0x6f, 0xf5,
  0x5c, 0x90, 0xbc, 0xd6, 0xba, 0xf5, 0xf3, 0xf0, 0x0f, 0x4a, 0x50, 0x4b, 0xfb, 0xfe, 0x7f, 0x9c,
  0xaa, 0x20, 0x45, 0x21, 0x53, 0x01, 0x00
};
static const size_t HTML_GZ_LEN = 21655;

  webServer.on("/", [&]() {
    webServer.sendHeader("Content-Encoding", "gzip");
    webServer.sendHeader("Cache-Control", "no-cache");
    webServer.setContentLength(HTML_GZ_LEN);
    webServer.send(200, "text/html", "");
    // Відправляємо по 4KB щоб не переповнити буфер
    const size_t chunkSize = 4096;
    size_t sent = 0;
    uint8_t buf[chunkSize];
    while (sent < HTML_GZ_LEN) {
      size_t toSend = min(chunkSize, HTML_GZ_LEN - sent);
      memcpy_P(buf, HTML_GZ + sent, toSend);
      webServer.sendContent((const char*)buf, toSend);
      sent += toSend;
    }
    webServer.sendContent("");
  });

  // JSON з даними — статичний буфер замість String-конкатенації.
  // String += на ESP32 фрагментує heap при кожному виклику realloc.
  // Статичний char buf[2200] виділяється один раз у стеку (loop-таск має 8KB стеку).
  // Розрахунок максимального розміру:
  //   числові поля (~60 полів × ~15 байт)   = ~900 байт
  //   рядки (comfort, futureBite, windFrom)  = ~300 байт
  //   масиви 4×15 елементів                 = ~240 байт
  //   score3h/scoreNd блоки                 = ~150 байт
  //   Разом: ~1590 байт → буфер 2200 (запас ×1.38)
  webServer.on("/data", [&]() {
    Serial.println("[/data] request received");

    int alt    = (int)((STD_SEA_PRESS_MM - dispPres) * 10.5f);
    byte sc    = calcFishScore();
    int fcNow  = forecastCurrentIdx();
    bool fcOk  = forecastValid && fcNow >= 0;
    bool isNight = (hrs >= 21 || hrs < 6);
    byte seasonNow = getSeason();
    byte moonP = getMoonPhase();
    bool rtOk  = rtWeather.valid && (millis()-rtWeather.fetchedAt) < 40UL*60*1000;

    // --- Рядкові поля (обчислюємо до буферизації) ---
    String seasonStr   = seasonDisplayName();
    String comfortStr  = comfortText();
    String futureStr   = futureBiteText();
    const char* windFr = (fcOk) ? windFromName(forecast[fcNow].windDir)   : "";
    const char* windTg = (fcOk) ? windTargetShore(forecast[fcNow].windDir): "";
    const char* ftNames[6] = {"мирна","хижак","карась","короп","к+кр","мирна"};
    char srBuf[6] = "", ssBuf[6] = "";
    if (dayCache.sunriseMin[0] != 0xFFFF) {
      snprintf(srBuf, sizeof(srBuf), "%02d:%02d",
               dayCache.sunriseMin[0]/60, dayCache.sunriseMin[0]%60);
      snprintf(ssBuf, sizeof(ssBuf), "%02d:%02d",
               dayCache.sunsetMin[0]/60,  dayCache.sunsetMin[0]%60);
    }

    // --- Масиви (рядки) ---
    // Кожен масив 15×int: максимум 15×("-128,") = 90 байт + 2 дужки = 92 байт
    char arrTH[96], arrHH[96], arrPH[96], arrPD[96], arrFH[96];
    {
      auto fillArr = [](char* dst, size_t dstSz, int* src, int n) {
        int pos = 0;
        dst[pos++] = '[';
        for (int i = 0; i < n && pos < (int)dstSz - 8; i++) {
          if (i) dst[pos++] = ',';
          pos += snprintf(dst + pos, dstSz - pos, "%d", src[i]);
        }
        dst[pos++] = ']';
        dst[pos]   = '\0';
      };
      fillArr(arrTH, sizeof(arrTH), tempHour,  15);
      fillArr(arrHH, sizeof(arrHH), humHour,   15);
      fillArr(arrPH, sizeof(arrPH), pressHour, 15);
      fillArr(arrPD, sizeof(arrPD), pressDay,  15);
      fillArr(arrFH, sizeof(arrFH), fishHour,  15);
    }

    // --- score3h ---
    int sc3raw = 255;
    {
      int idx3 = fcNow;
      if (forecastValid && idx3 >= 0 && idx3 + 3 < FORECAST_HOURS) {
        int s3 = 60;
        int dp3 = (int)forecast[idx3+3].pressure - (int)forecast[idx3].pressure;
        if      (dp3 <= -3) s3 -= 25;
        else if (dp3 >= 3)  s3 -= 20;
        else if (dp3 == 0)  s3 += 8;
        uint8_t w3 = forecast[idx3+3].wind;
        if      (w3 >= 9) s3 -= 28;
        else if (w3 >= 6) s3 -= 15;
        else if (w3 >= 3) s3 -= 5;
        else if (w3 <= 2) s3 += 3;
        uint8_t h3 = forecast[idx3+3].hum;
        if      (h3 > 85 && abs(dp3) < 3) s3 += 6;
        else if (h3 < 30)                 s3 -= 6;
        else if (h3 >= 60 && h3 <= 80)    s3 += 4;
        float t3 = (float)forecast[idx3+3].temp;
        byte mo3 = rtc.now().month();
        if      (mo3>=6&&mo3<=8) { if(t3>30.0f)s3-=12; else if(t3>=18.0f&&t3<=26.0f)s3+=5; }
        else if (mo3>=3&&mo3<=5) { if(t3>=10.0f&&t3<=20.0f)s3+=5; else if(t3<6.0f)s3-=8; }
        uint8_t wid3 = forecast[idx3+3].wid;
        if      (wid3 >= 95) s3 -= 35;
        else if (wid3 >= 80) s3 -= 15;
        else if ((wid3==51||wid3==61) && abs(dp3)<2) s3 += 8;
        if (useSpawn && isSpawnPeriod()) s3 -= 15;
        s3 = constrain(s3, 0, 100);
        sc3raw = (s3 >= 75) ? 3 : (s3 >= 50) ? 2 : (s3 >= 25) ? 1 : 0;
      }
    }

    // --- scoreNd ---
    int scNdRaw = 255;
    {
      int idxNd = fcNow;
      if (forecastValid && idxNd >= 0 && idxNd + 27 < FORECAST_HOURS) {
        int sndSum = 0, sndCnt = 0;
        for (int di = 24; di <= 26; di++) {
          int ii = idxNd + di;
          if (ii >= FORECAST_HOURS) break;
          int snd = 60;
          int dpNd = (int)forecast[ii].pressure - (int)forecast[idxNd].pressure;
          if      (dpNd <= -3) snd -= 25;
          else if (dpNd >= 3)  snd -= 20;
          else if (dpNd == 0)  snd += 8;
          uint8_t wNd = forecast[ii].wind;
          if      (wNd >= 9) snd -= 28;
          else if (wNd >= 6) snd -= 15;
          else if (wNd >= 3) snd -= 5;
          else if (wNd <= 2) snd += 3;
          uint8_t hNd = forecast[ii].hum;
          if      (hNd > 85 && abs(dpNd) < 3) snd += 6;
          else if (hNd < 30)                  snd -= 6;
          else if (hNd >= 60 && hNd <= 80)    snd += 4;
          float tNd = (float)forecast[ii].temp;
          byte moNd = rtc.now().month();
          if      (moNd>=6&&moNd<=8) { if(tNd>30.0f)snd-=12; else if(tNd>=18.0f&&tNd<=26.0f)snd+=5; }
          else if (moNd>=3&&moNd<=5) { if(tNd>=10.0f&&tNd<=20.0f)snd+=5; else if(tNd<6.0f)snd-=8; }
          uint8_t widNd = forecast[ii].wid;
          if      (widNd >= 95) snd -= 35;
          else if (widNd >= 80) snd -= 15;
          else if ((widNd==51||widNd==61) && abs(dpNd)<2) snd += 8;
          if (useSpawn && isSpawnPeriod()) snd -= 15;
          snd = constrain(snd, 0, 100);
          sndSum += snd; sndCnt++;
        }
        if (sndCnt > 0) {
          int sndAvg = sndSum / sndCnt;
          scNdRaw = (sndAvg >= 75) ? 3 : (sndAvg >= 50) ? 2 : (sndAvg >= 25) ? 1 : 0;
        }
      }
    }

    // --- Формуємо JSON одним snprintf у статичний буфер ---
    static char jbuf[2200];
    int pos = 0;
    pos += snprintf(jbuf+pos, sizeof(jbuf)-pos,
      "{"
      "\"temp\":%.1f,"
      "\"hum\":%d,"
      "\"pres\":%.1f,"
      "\"rain\":%d,"
      "\"delta\":%d,"
      "\"alt\":%d,"
      "\"fishScore\":%d,"
      "\"basePress\":%.1f,"
      "\"baseConfigured\":%s,"
      "\"deltaReady\":%s,"
      "\"pressureSamples\":%d,"
      "\"warmup\":%s,"
      "\"season\":%d,"
      "\"seasonName\":\"%s\","
      "\"windNow\":%d,"
      "\"windDir\":%d,"
      "\"windFrom\":\"%s\","
      "\"windTarget\":\"%s\","
      "\"cloud\":%d,"
      "\"tempTrend\":%d,"
      "\"comfort\":\"%s\","
      "\"futureBite\":\"%s\","
      "\"fishType\":%d,"
      "\"fishName\":\"%s\","
      "\"useTime\":%d,"
      "\"useSpawn\":%d,"
      "\"useMoon\":%d,"
      "\"waterType\":%d,"
      "\"isSpawn\":%s,"
      "\"hour\":%d,"
      "\"tempOut\":%d,"
      "\"humOut\":%d,"
      "\"fcStatus\":%d,"
      "\"tzMode\":%d,"
      "\"moonPhase\":%d,"
      "\"moonName\":\"%s\","
      "\"moonIcon\":\"%s\","
      "\"sunrise\":\"%s\","
      "\"sunset\":\"%s\","
      "\"fcWid\":%d,"
      "\"fcPop\":%d,"
      "\"isNight\":%s,"
      "\"uptimeMs\":%lu,"
      "\"rtValid\":%s,"
      "\"rtPrecip\":%.1f,"
      "\"rtWcode\":%d,"
      "\"rtTemp\":%.1f,"
      "\"rtWind\":%.1f,"
      "\"rtHum\":%d,"
      "\"rtPres\":%.1f,",
      // --- значення ---
      isnan(dispTemp)||isinf(dispTemp) ? 0.0f : dispTemp,
      (int)dispHum,
      isnan(dispPres)||isinf(dispPres) ? 0.0f : dispPres,
      dispRain,
      delta,
      alt,
      sc == 255 ? 255 : (int)sc,
      isnan(SEA_PRESS_MM) ? 0.0f : SEA_PRESS_MM,
      basePressureSet() ? "true" : "false",
      deltaReady        ? "true" : "false",
      (int)pressureSampleCount,
      startupWarmup()   ? "true" : "false",
      (int)seasonNow,
      seasonStr.c_str(),
      fcOk ? (int)forecast[fcNow].wind    : 0,
      fcOk ? (int)forecast[fcNow].windDir : -1,
      windFr,
      windTg,
      fcOk ? (int)forecast[fcNow].cloud   : -1,
      (forecastValid && fcNow >= 0) ? tempTrendC() : 0,
      comfortStr.c_str(),
      futureStr.c_str(),
      (int)fishType,
      ftNames[fishType < 6 ? fishType : 0],
      useTime  ? 1 : 0,
      useSpawn ? 1 : 0,
      useMoon  ? 1 : 0,
      (int)waterType,
      (useSpawn && isSpawnPeriod()) ? "true" : "false",
      (int)hrs,
      fcOk ? (int)forecast[fcNow].temp : -999,
      fcOk ? (int)forecast[fcNow].hum  : -1,
      forecastValid ? 0 : 1,
      (int)tzMode,
      (int)moonP,
      moonPhaseName(moonP),
      moonPhaseIcon(moonP),
      srBuf,
      ssBuf,
      fcOk ? (int)forecast[fcNow].wid  : -1,
      fcOk ? (int)forecast[fcNow].pop  : -1,
      isNight ? "true" : "false",
      (unsigned long)millis(),
      rtOk    ? "true" : "false",
      isnan(rtWeather.precipitation)   ? 0.0f : rtWeather.precipitation,
      (int)rtWeather.weatherCode,
      isnan(rtWeather.temperature)     ? 0.0f : rtWeather.temperature,
      isnan(rtWeather.windSpeed)       ? 0.0f : rtWeather.windSpeed,
      (int)rtWeather.humidity,
      isnan(rtWeather.surfacePressure) ? 0.0f : rtWeather.surfacePressure
    );
    // Масиви
    pos += snprintf(jbuf+pos, sizeof(jbuf)-pos,
      "\"tempHour\":%s,"
      "\"humHour\":%s,"
      "\"pressHour\":%s,"
      "\"pressDay\":%s,"
      "\"fishHour\":%s,"
      "\"score3h\":%d,"
      "\"scoreNd\":%d}",
      arrTH, arrHH, arrPH, arrPD, arrFH,
      sc3raw  == 255 ? 255 : sc3raw,
      scNdRaw == 255 ? 255 : scNdRaw
    );

    if (pos < 10 || pos >= (int)sizeof(jbuf)) {
      Serial.printf("[/data] ERROR: pos=%d\n", pos);
      webServer.send(500, "application/json", "{\"error\":\"buf\",\"fishScore\":255}");
      return;
    }
    Serial.printf("[/data] OK, len=%d\n", pos);
    webServer.sendHeader("Cache-Control", "no-cache");
    webServer.send(200, "application/json", jbuf);
  });


  // Снасть — детально з поясненням
  webServer.on("/tackle", [&]() {
    byte score   = calcFishScore();
    byte season2 = getSeason();
    byte h2      = (byte)hrs;
    bool mornEve = (h2 >= 5 && h2 <= 9) || (h2 >= 18 && h2 <= 22);
    bool isDay   = (h2 >= 7 && h2 <= 20);

    int fcIdx2 = forecastCurrentIdx();
    bool weatherCloudy2 = forecastValid && fcIdx2 >= 0 &&
                          (forecast[fcIdx2].wid >= 3 || forecast[fcIdx2].cloud >= 60);
    bool fcRainNow2     = forecastValid && fcIdx2 >= 0 &&
                          (forecast[fcIdx2].wid >= 51 || forecast[fcIdx2].pop > 60);
    bool fcHot2         = forecastValid && fcIdx2 >= 0 && forecast[fcIdx2].temp > 26;
    uint8_t fcWind2     = forecastValid && fcIdx2 >= 0 ? forecast[fcIdx2].wind : 0;
    bool highPress2     = pressJumped && (dispPres - SEA_PRESS_MM) > 5.0f; // тільки під час стрибка вгору
    bool lowPress2      = lowPressTackleColumn();
    bool strongWind2    = (fcWind2 >= 6);

    String tackleCode;
    String reason;

    if (score == 255) {
      tackleCode = "S:..."; reason = F("Ще збираємо дані тиску");
    } else if (score == 0) {
      if (highPress2 || strongWind2) {
        tackleCode = "S:D";
        reason = strongWind2
          ? F("Вітер ≥6 м/с — поплавок зносить, донка лежить нерухомо")
          : F("Тиск різко зріс — риба притиснута до дна, флет або лежачий гачок");
      } else if (lowPress2 || fcRainNow2) {
        tackleCode = "S:P";
        reason = fcRainNow2
          ? F("Дощ + низький тиск — риба в пів-воді, поплавок опускається повільно")
          : F("Низький або нещодавно змінений тиск — риба стоїть у товщі, легкий поплавок");
      } else {
        tackleCode = "S:D";
        reason = F("Пасивна риба — донка лежить тихо, не лякає");
      }
    } else if (score == 1) {
      if (strongWind2 || highPress2) {
        tackleCode = "S:D";
        reason = strongWind2
          ? F("Є хвиля — поплавок смикає і лякає рибу, донка надійніша")
          : F("Тиск нещодавно зріс — риба ближче до дна, донка ефективніша");
      } else if (fcRainNow2 && !strongWind2) {
        tackleCode = "S:P";
        reason = F("Дощик аерує воду — риба піднялась, поплавок точніший");
      } else {
        tackleCode = "S:D&P";
        reason = F("50/50 — обидві снасті рівноцінні, спробуйте обидві");
      }
    } else {
      // Good / Great
      if (strongWind2) {
        tackleCode = "S:D";
        reason = F("Вітер ≥6 м/с — поплавок здуває, навіть при відмінному кльові донка краща");
      } else if (highPress2) {
        tackleCode = "S:D";
        reason = F("Підвищений тиск — риба тримається дна, флет або покладка");
      } else if (season2 == 3) {
        if (mornEve) {
          tackleCode = "S:D&P";
          reason = F("Ранок/вечір влітку — риба активна у всіх шарах, обидві снасті");
        } else if (fcHot2 && !weatherCloudy2 && !fcRainNow2) {
          tackleCode = "S:P";
          reason = F("Спека і сонце — риба у верхньому шарі, поплавок повільно опускає насадку");
        } else {
          tackleCode = "S:D&P";
          reason = F("Хмарно або помірна температура — риба активна на всій глибині");
        }
      } else {
        if (!isDay) {
          tackleCode = "S:D";
          reason = F("Ніч — тільки донка, риба тримається дна");
        } else if (fcRainNow2 && !strongWind2) {
          tackleCode = "S:P";
          reason = F("Дощик без вітру — риба піднялась, поплавок з легкою насадкою");
        } else {
          tackleCode = "S:D&P";
          reason = F("Хороші умови — обидві снасті ефективні");
        }
      }
    }

    // Примітка про нерест до снасті
    if (useSpawn && isSpawnPeriod()) {
      reason = String(F("🐣 Нерест — ")) + reason;
    }

    String json = "{";
    json += "\"tackle\":\"" + tackleCode + "\",";
    json += "\"reason\":\"" + reason + "\",";
    json += "\"season\":" + String(season2) + ",";
    json += "\"score\":" + String(score == 255 ? 255 : score) + ",";
    json += "\"hot\":" + String(fcHot2 ? "true" : "false") + ",";
    json += "\"cloudy\":" + String(weatherCloudy2 ? "true" : "false") + ",";
    json += "\"rain\":" + String(fcRainNow2 ? "true" : "false") + ",";
    json += "\"wind\":" + String(fcWind2) + ",";
    json += "\"morningEvening\":" + String(mornEve ? "true" : "false") + "}";
    webServer.send(200, "application/json", json);
  });

  // Кльов "протилежної" риби (мирна↔хижа)
  webServer.on("/oppfish", [&]() {
    // Визначаємо тип протилежної риби
    byte oppType;
    const char* oppName;
    if (fishType == 1) {
      // хижа → мирна (карась як найчутливіший представник)
      oppType = 2;
      oppName = "\u043a\u0430\u0440\u0430\u0441\u044c";
    } else {
      // будь-яка мирна → хижа
      oppType = 1;
      oppName = "\u0445\u0438\u0436\u0430\u043a";
    }
    // Тимчасово підміняємо fishType для розрахунку
    byte savedType = fishType;
    fishType = oppType;
    byte oppScore = calcFishScore();
    fishType = savedType;

    const char* scoreNames[4] = {"Bad","50%","Good","Grt!"};
    String json = "{";
    json += "\"oppName\":\"" + String(oppName) + "\",";
    json += "\"oppScore\":" + String(oppScore == 255 ? 255 : (int)oppScore) + ",";
    json += "\"oppText\":\"" + String(oppScore == 255 ? "..." : scoreNames[oppScore]) + "\"";
    json += "}";
    webServer.send(200, "application/json", json);
  });

  // Порада рибалці — залежить від score, fishType, сезону, часу доби
  webServer.on("/hint", [&]() {
    byte sc     = calcFishScore();
    byte season = getSeason();
    byte h      = (byte)hrs;
    bool morn   = (h >= 5 && h <= 9);
    bool eve    = (h >= 18 && h <= 22);
    bool dayT   = (h >= 10 && h <= 17);
    bool night  = !morn && !eve && !dayT;
    int  fcIdx3 = forecastCurrentIdx();
    bool hot    = forecastValid && fcIdx3 >= 0 && forecast[fcIdx3].temp > 26;
    bool warm   = forecastValid && fcIdx3 >= 0 && forecast[fcIdx3].temp > 18;
    bool cold   = forecastValid && fcIdx3 >= 0 && forecast[fcIdx3].temp < 8;
    bool cloudy = forecastValid && fcIdx3 >= 0 && (forecast[fcIdx3].wid >= 3 || forecast[fcIdx3].cloud >= 60);
    bool rain   = forecastValid && fcIdx3 >= 0 && forecast[fcIdx3].wid >= 51;
    bool storm  = forecastValid && fcIdx3 >= 0 && forecast[fcIdx3].wid >= 95;
    uint8_t ws  = forecastValid && fcIdx3 >= 0 ? forecast[fcIdx3].wind : 0;
    bool rising = delta > 30;
    bool falling= delta < -30;
    bool stable = abs(delta) <= 30;
    bool isHunter = (fishType == 1);
    bool isKaras  = (fishType == 2 || fishType == 4);
    bool isKorop  = (fishType == 3 || fishType == 4);

    // --- Причина кльову (коротко) ---
    String reason;
    if (sc == 255) {
      reason = "";
    } else if (pressJumped) {
      float gradH = (jumpStartMs > 0 && stableStartMs > 0 && stableStartMs > jumpStartMs)
                    ? (float)(stableStartMs - jumpStartMs) / 3600000.0f : 0.0f;
      if (gradH > 0 && gradH < 3.0f)
        reason = "⚡ Різкий стрибок тиску — риба в шоці, адаптація";
      else
        reason = "📉 Зміна тиску — риба перебудовує плавальний міхур";
    } else if (abs(delta) >= 160) {
      reason = falling ? "📉 Тиск швидко падає — риба ховається" : "📈 Тиск різко росте — риба дезорієнтована";
    } else if (abs(delta) >= 80) {
      reason = falling ? "↘️ Тиск помірно падає" : "↗️ Тиск помірно росте";
    } else if (stable) {
      reason = "✅ Тиск стабільний — риба адаптована, клює нормально";
      // Якщо > 15мм від бази — підказка про калібрування, не про рибу
      float diff3 = dispPres - SEA_PRESS_MM;
      if (fabsf(diff3) > 15.0f)
        reason += " (перевір базовий тиск у налаштуваннях)";
    }
    if (storm)
      reason = "⛈️ Гроза — різкий перепад тиску і освітлення";
    else if (rain && reason.length() == 0)
      reason = "🌧️ Дощ аерує воду — риба стає активнішою";
    if (ws >= 9)
      reason += (reason.length() > 0 ? " · " : "") + String("💨 Шторм: хвиля ховає рибу");
    else if (ws >= 6)
      reason += (reason.length() > 0 ? " · " : "") + String("💨 Вітер ≥6 м/с");

    // --- Напрям і місце ---
    String direction;
    if (sc == 255) {
      direction = "";
    } else if (night) {
      direction = "🌙 Вночі риба тримається дна на ямах і глибоких береговинах.";
    } else if (storm) {
      direction = "⛈️ До грози — відходьте від води і чекайте: після грози риба жере.";
    } else if (ws >= 9) {
      direction = "💨 При шторму: шукайте захищені бухти і підвітряний берег.";
    } else if (ws >= 6) {
      direction = "💨 Ловіть з підвітряного берегу або шукайте захищені місця.";
    } else if (sc == 0 && pressJumped) {
      direction = "⏳ Почекайте 1-3 год після стрибка тиску — риба сама вийде.";
    } else if (sc == 0) {
      direction = falling
        ? "↘️ Риба пасивна. Ідіть на глибину — там стабільніший тиск."
        : "↗️ Риба пригнічена. Ями і глибокі прибережні ділянки.";
    } else if (season == 3) {
      // ЛІТО
      if (morn) {
        direction = isHunter
          ? "🌅 Ранок: мілководдя 0.5-1.5 м, кидайте вздовж берегової рослинності."
          : "🌅 Ранок: прибережні мілини де вода прогрілась, 0.5-2 м від берега.";
      } else if (eve) {
        direction = isHunter
          ? "🌇 Вечір: виходи і затоки, мілководдя де риба полює на малька."
          : "🌇 Вечір: прибережна зона до 1.5 м — карась і короп виходять годуватись.";
      } else if (hot && !cloudy) {
        // ДЕНЬ + СПЕКА → не говоримо "сонце жарить" ввечері!
        direction = isHunter
          ? "☀️ Спека: щука пішла на глибину 3-6 м до коряг і ям."
          : "☀️ Спека: риба стоїть у тіні — під листям латаття, у нависаючих кущах.";
      } else {
        direction = isHunter
          ? "⛅ Хмарно: риба активна по всій товщі, пробуйте і берег і середину."
          : "⛅ Хмарно або дощ: ловіть на глибині 1.5-2.5 м, риба рівномірна.";
      }
    } else if (season == 2) {
      // ВЕСНА
      direction = isHunter
        ? "🌿 Весна: щука на нерестилищах — мілководдя з рослинністю, до 1 м."
        : "🌿 Весна: шукайте прогріті місця — мілководдя на сонці, захищені затоки.";
    } else if (season == 4) {
      // ОСІНЬ
      if (dayT || morn || eve) {
        direction = isHunter
          ? "🍂 Осінь: щука на ямах і перепадах глибин, 3-5 м."
          : "🍂 Осінь: риба концентрується на глибоких ділянках 2-4 м, прикорм обов'язковий.";
      } else {
        direction = "🍂 Осіннє ніч: риба на дні ям, тільки донка.";
      }
    } else if (season == 1) {
      // ЗИМА
      direction = isHunter
        ? "❄️ Зима: щука стоїть у ямах 3-5 м. Полудень — єдиний активний час."
        : "❄️ Зима: риба на максимальній глибині. Ловіть повільно і точково.";
    } else {
      direction = "";
    }
    if (forecastValid && fcIdx3 >= 0 && ws >= 2 && ws < 9) {
      direction += (direction.length() > 0 ? " " : "");
      direction += "💨 Вітер з ";
      direction += windFromName(forecast[fcIdx3].windDir);
      direction += " — перевірте ";
      direction += windTargetShore(forecast[fcIdx3].windDir);
      direction += ": туди зносить корм і кисень.";
    }

    // --- Основна порада ---
    String hint;

    if (sc == 255) {
      hint = F("Ще збираємо дані тиску. Перевірте налаштування базового тиску місцевості.");
    }
    // --- STORM ---
    else if (storm) {
      if (isHunter) hint = F("Гроза активує хижака перед початком. Кидайте попер вздовж берега поки є час.");
      else          hint = F("Перед грозою — короткий жор. Ставте снасть зараз і будьте готові відійти.");
    }
    // --- NIGHT ---
    else if (night && sc <= 1) {
      hint = isHunter
        ? F("Вночі хижак активний але локально. Великі силіконові приманки на ямах.")
        : F("Ніч при поганому тиску — риба спить. Залиште донку і відпочивайте.");
    }
    // --- BAD SCORE ---
    else if (sc == 0) {
      if (pressJumped && isHunter)
        hint = F("Стрибок тиску пригнічує навіть хижака. Повільна проводка — щука б'є рефлекторно навіть без апетиту.");
      else if (pressJumped && isKaras)
        hint = F("Різка зміна тиску загоняє карася на дно. Дрібний гачок з манкою прямо на дно — єдиний шанс.");
      else if (pressJumped && isKorop)
        hint = F("Різка зміна тиску глушить коропа. Важка донка, мінімум шуму і насадка на дні.");
      else if (pressJumped)
        hint = F("Риба адаптується до нового тиску. Зробіть паузу і перевірте снасть через 1-2 години.");
      else if (falling && isHunter)
        hint = F("Тиск падає — хижак млявий. Дрібний джиг або черв'як на дні — великі приманки не працюють.");
      else if (falling)
        hint = F("Тиск падає — риба пасивна. Зменшіть гачок і насадку, ловіть повільно.");
      else if (rising && isHunter)
        hint = F("Тиск різко росте — хижак дезорієнтований. Зачекайте стабілізації 1-2 год.");
      else if (rising)
        hint = F("Тиск різко росте — мирна риба сховалась. Горох або кукурудза на дні — ловлять навіть в пасивний час.");
      else if (ws >= 9)
        hint = F("Шторм заганяє рибу на дно. Важка донка з великим грузилом — єдиний варіант.");
      else
        hint = F("Несприятливий час. Поміняйте місце на глибше і перевірте наживку.");
    }
    // --- 50% SCORE ---
    else if (sc == 1) {
      if (night) {
        hint = isHunter
          ? F("Ніч при нестабільному тиску: ями і коряжники. Повільний силікон на дні.")
          : F("Ніч, нестійкий клів: залиште донку з прикормом і не турбуйте місце.");
      }
      else if (isHunter && rising)
        hint = F("Тиск повільно росте — хижак прокидається. Воблери на середній глибині, рівномірна проводка.");
      else if (isHunter && falling)
        hint = F("Тиск іще падає але повільно — щука може вдарити. Офсетний гачок з силіконом на дні.");
      else if (isHunter && stable)
        hint = F("Тиск стабілізується — непоганий час для щуки. Попери по краю водоростей, короткі паузи.");
      else if (isKaras && morn)
        hint = F("50% вранці — шукайте місця з водоростями. Червоний черв'як на дрібному гачку.");
      else if (isKorop && eve)
        hint = F("Ввечері короп може вийти до берегових брівок. Кукурудза або горох на донці.");
      else if (isKaras && eve)
        hint = F("Ввечері карась може клювати у самого берегу на дні. Тихіше рухайтесь.");
      else if (rain && !isHunter)
        hint = F("Дрібний дощ при помірному тиску — карась і короп активніші. Прикорм з хлібом прискорить результат.");
      else if (cloudy && !isHunter)
        hint = F("Хмарно — риба не боїться тіні. Ловіть ближче до поверхні ніж зазвичай.");
      else if (season == 2)
        hint = F("Весна, нестійке 50% — риба шукає прогріті місця. Мілководдя на сонці дасть результат.");
      else if (season == 4)
        hint = F("Осінь, нестійкий клів — великий прикорм не допомагає. Точкова ловля без шуму.");
      else
        hint = F("Нестійкий клів. Частіше міняйте місце і наживку — активний пошук краще очікування.");
    }
    // --- GOOD/GREAT SCORE ---
    else if (sc >= 2) {
      if (night) {
        hint = isHunter
          ? F("Ніч при стабільному тиску — хижак активний. Великий силікон на ямах, повільна ступінчаста проводка.")
          : F("Ніч, хороший тиск: донка на ямі з прикормом. Тихо і не рухайтесь — риба підійде сама.");
      }
      else if (season == 3 && morn) {
        if (isHunter)
          hint = F("Ранній ранок влітку — найкращий час для щуки. Попер або джиг на мілководді.");
        else if (isKorop)
          hint = F("Ранній ранок влітку — короп виходить годуватись. Донка з кукурудзою або бойлом біля брівки.");
        else if (isKaras)
          hint = F("Ранній ранок влітку — карась клює поверхнево. Поплавок з хлібом або опариком.");
        else
          hint = F("Ранній ранок влітку — золотий час. Обидві снасті, ловіть до 9-ї.");
      }
      else if (season == 3 && eve) {
        if (isHunter)
          hint = F("Вечірня зоря влітку — щука активна на мілководді. Великий попер або уокер по тихій воді.");
        else if (isKorop)
          hint = F("Вечір влітку — короп підходить ближче до берега. Донка з кукурудзою або горохом.");
        else if (isKaras)
          hint = F("Вечір влітку — карась клює до темряви. Поплавок з горохом або кукурудзою в 30 см від дна.");
        else
          hint = F("Вечірній жор влітку — ловіть до темряви. Прикормте і не рухайтесь.");
      }
      else if (season == 3 && dayT && hot && !cloudy) {
        // Спека і сонце — тільки якщо вдень, не плутаємо з вечором!
        if (isHunter)
          hint = F("Спека і сонце — щука на глибині. Джиг 4-6 м, повільна ступінчаста проводка.");
        else if (isKorop)
          hint = F("Денна спека: короп у тіні латаття. Поплавок з насадкою на 30-50 см від поверхні біля рослин.");
        else
          hint = F("Денна спека: риба у тіні на мілководді. Легкий поплавок під нависаючі кущі.");
      }
      else if (season == 3 && dayT && !hot && !cloudy) {
        if (isHunter)
          hint = F("Сонячний день влітку: щука тримається тіні біля коряг і водної рослинності. Повільна проводка.");
        else if (isKorop)
          hint = F("Сонячний день влітку: короп у тіні. Поплавок під нависаючими кущами або край латаття.");
        else
          hint = F("Сонячний день влітку: шукайте затінені місця і краї рослинності.");
      }
      else if (season == 3 && dayT && cloudy) {
        if (isHunter)
          hint = F("Хмарний день влітку — щука активна. Воблер середньої заглибини вздовж берега.");
        else
          hint = F("Хмарний день влітку — риба активна весь день. Обидві снасті, глибина 1-2 м.");
      }
      else if (season == 2 && rising) {
        if (isHunter)
          hint = F("Весна, тиск росте — найкращий час для щуки. Великі воблери і блешні, активна проводка.");
        else
          hint = F("Весна, тиск росте — риба виходить з ям. Мілководдя де прогрівається вода — ваше місце.");
      }
      else if (season == 4 && (dayT || morn || eve)) {
        if (isHunter)
          hint = F("Осінній день — щука нагулює жир. Великий джиг на глибоких ямах, повільна проводка.");
        else if (isKaras)
          hint = F("Осінній день — карась на глибоких ділянках. Донка з прикормом на 2-4 м.");
        else
          hint = F("Осінній день — золотий час для великої риби. Донка з крупною насадкою на ямі.");
      }
      else if (season == 1 && (dayT)) {
        if (isHunter)
          hint = F("Зима, полудень — щука єдиний активний момент. Вертушка або блешня, повільно і глибоко.");
        else
          hint = F("Зима, полудень — риба повільна. Мінімальний гачок, мотиль або червоний черв'як.");
      }
      else if (season == 1 && morn) {
        hint = isHunter
          ? F("Зимовий ранок: щука ще не прокинулась. Ловіть з 10:00 — до того марно.")
          : F("Зимовий ранок: риба малоактивна. Зачекайте прогріву — ловіть після 10:00.");
      }
      else if (season == 1 && eve) {
        hint = F("Зимовий вечір: риба пасивна, йде на дно. Якщо клює — тільки донка на ямах.");
      }
      else if (season == 2 && eve) {
        hint = isHunter
          ? F("Весняний вечір: хижак активний після прогріву води. Воблер вздовж берегових рослин.")
          : F("Весняний вечір: мирна риба виходить на прибережне мілководдя. Ловіть у прогрітих заплавах.");
      }
      else if (season == 2 && morn && !rising) {
        hint = isHunter
          ? F("Весняний ранок зі стабільним тиском: щука активна на нерестилищах. Блешня або попер.")
          : F("Весняний ранок: карась і короп виходять на прогріті мілини. Поплавок з черв'яком.");
      }
      else if (season == 4 && night) {
        hint = F("Осіння ніч: риба пасивна, тримається дна. Тільки важка донка на глибоких ямах.");
      }
      else if (rain && !storm) {
        if (isHunter)
          hint = F("Дощ активує хижака. Поверхневі приманки вздовж берега — щука атакує шум від краплин.");
        else
          hint = F("Дощ без грози — відмінний клів. Прикормте і ловіть — риба менш обережна в дощ.");
      }
      else if (stable && sc == 3) {
        if (isHunter)
          hint = F("Стабільний тиск, відмінний клів — атакуйте найкращі місця. Великі приманки сьогодні працюють.");
        else if (isKorop)
          hint = F("Ідеальний день для коропа. Прикормте точку і тримайте снасть на брівці — шанс на трофей високий.");
        else if (isKaras)
          hint = F("Ідеальний день для карася. Прикормте місце, зачекайте 10 хв — постійний клів гарантований.");
        else
          hint = F("Ідеальний клів. Ставте найбільший гачок — сьогодні можна спіймати трофей.");
      }
      else {
        if (isHunter)
          hint = F("Хороший клів для хижака. Поспішайте — активні вікна тривають 1-2 год.");
        else
          hint = F("Хороший клів. Прикормте місце і не відходьте — кращий час зараз.");
      }
    }
    else {
      hint = F("Ще збираємо дані тиску. Перевірте налаштування базового тиску місцевості.");
    }

    // Нотатка про нерест — додається поверх основної поради
    String spawnNote = "";
    if (useSpawn && isSpawnPeriod()) {
      if (fishType == 1) {
        spawnNote = F("🐣 Нерест щуки. Риба біля мілководдя з рослинністю, але майже не їсть. У більшості регіонів — заборона лову.");
      } else if (fishType == 2 || fishType == 5 || fishType == 0) {
        spawnNote = F("🐣 Нерест карася. Риба на мілководді і серед рослин, клів різко знижений. Перевірте місцеві правила лову.");
      } else if (fishType == 3 || fishType == 4) {
        spawnNote = F("🐣 Нерест коропа. Риба б'ється і плескається на мілководді, годуватись не буде. Дотримуйтесь правил рибальства.");
      }
    }

    // Топ-3 фактори
    struct Factor { const char* name; int weight; bool negative; };
    Factor factors[10];
    int nf = 0;
    int absDelta2 = abs(delta);
    { // Тиск — НЕГАТИВНИЙ якщо стрибок або різка зміна, ПОЗИТИВНИЙ якщо стабільний
      if (pressJumped) {
        int pw = 45;
        factors[nf++] = {"⚡ Стрибок тиску", pw, true};
      } else if (absDelta2 >= 200) {
        const char* pname = (delta < 0) ? "📉 Тиск швидко падає" : "📈 Тиск різко росте";
        factors[nf++] = {pname, 35, true};
      } else if (absDelta2 >= 90) {
        const char* pname = (delta < 0) ? "📉 Тиск помірно падає" : "📈 Тиск помірно росте";
        factors[nf++] = {pname, 20, true};
      } else if (absDelta2 >= 30) {
        const char* pname = (delta < 0) ? "↘️ Тиск трохи падає" : "↗️ Тиск трохи росте";
        factors[nf++] = {pname, 8, true};
      } else {
        // Стабільний тиск — завжди добрий знак незалежно від абсолютного значення
        factors[nf++] = {"✅ Тиск стабільний", 20, false};
        // Якщо відхилення > 15мм — ймовірно база введена неточно (не штраф, а підказка)
        float diff2 = dispPres - SEA_PRESS_MM;
        if (fabsf(diff2) > 15.0f)
          factors[nf++] = {diff2 > 0 ? "⚙️ Можливо база занижена" : "⚙️ Можливо база завищена", 2, true};
      }
    }
    { byte sph = spawnPhase();
      if (sph == 2) factors[nf++] = {"🐣 Пік нересту", 35, true};
      else if (sph == 1) factors[nf++] = {"🐣 Початок нересту", 15, true};
      else if (sph == 3) factors[nf++] = {"🐟 Після нересту — жор", 20, false};
    }
    if (forecastValid && fcIdx3 >= 0) {
      uint8_t ws2 = forecast[fcIdx3].wind;
      int wp = (ws2 >= 9) ? 30 : (ws2 >= 6) ? 20 : (ws2 >= 3) ? 8 : 0;
      if (wp > 0) factors[nf++] = {"💨 Вітер", wp, true};
      else if (ws2 <= 2) factors[nf++] = {"🌬️ Штиль", 8, false}; // штиль — позитив
      float tc2 = (float)forecast[fcIdx3].temp;
      byte mo2 = rtc.now().month();
      int tp = 0;
      if (mo2>=6&&mo2<=8&&tc2>30.0f) tp=20; else if (mo2>=6&&mo2<=8&&tc2<14.0f) tp=15;
      else if (mo2>=3&&mo2<=5&&tc2<6.0f) tp=15;
      if (tp > 0) factors[nf++] = {"🌡️ Температура", tp, true};
      uint8_t hum2 = forecast[fcIdx3].hum;
      if      (hum2 < 30) factors[nf++] = {"🏜️ Суха погода", 10, true};
      else if (hum2 > 85) factors[nf++] = {"💧 Висока вологість", 8, false};
      uint8_t wid2 = forecast[fcIdx3].wid;
      if      (wid2 >= 95) factors[nf++] = {"⛈️ Гроза", 40, true};
      else if (wid2 >= 80) factors[nf++] = {"🌧️ Зливи", 20, true};
      else if (wid2 >= 51) factors[nf++] = {"🌦️ Дощ", 8, false}; // легкий дощ — позитив
    }
    { int tb2 = timeBonus();
      if (tb2 >= 10) factors[nf++] = {"🌅 Кращий час доби", 12, false};
      else if (tb2 <= -10) factors[nf++] = {"🌙 Пасивний час", 10, true};
    }
    // Місяць — невеликий бонус якщо активна фаза
    if (useMoon) {
      byte mp = getMoonPhase();
      if (mp <= 2 || mp >= 27)        factors[nf++] = {"🌑 Новий місяць", 4, false};
      else if (mp >= 12 && mp <= 17)  factors[nf++] = {"🌕 Повня", 4, false};
    }
    // Напрямок вітру
    if (forecastValid && fcIdx3 >= 0) {
      uint16_t wdir3 = forecast[fcIdx3].windDir;
      uint8_t  wspd3 = forecast[fcIdx3].wind;
      if (wspd3 >= 3) {
        if (wdir3 >= 135 && wdir3 <= 315)
          factors[nf++] = {"🧭 Вітер з заходу/півдня", 4, false};
        else
          factors[nf++] = {"🧭 Вітер з півночі/сходу", 4, true};
      }
    }
    // Ранковий/вечірній клюв карася влітку
    if (useTime && (fishType == 2 || fishType == 0 || fishType == 4 || fishType == 5)) {
      byte mo_f = rtc.now().month();
      byte h_f  = (byte)hrs;
      if (mo_f >= 6 && mo_f <= 8) {
        if ((h_f >= 5 && h_f <= 8) || (h_f >= 19 && h_f <= 21))
          factors[nf++] = {"🌅 Зоря — пік кльову карася", 4, false};
        else if (h_f >= 11 && h_f <= 16)
          factors[nf++] = {"☀️ Обід — карась ховається", 4, true};
      }
    }
    // Сортування за вагою (спадання)
    for (int i = 0; i < nf-1; i++)
      for (int j = 0; j < nf-1-i; j++)
        if (factors[j].weight < factors[j+1].weight) { Factor tmp=factors[j]; factors[j]=factors[j+1]; factors[j+1]=tmp; }
    // Перевірка логічної узгодженості: якщо score >= 2 (Good/Grt), не показуємо
    // дуже важкі негативні фактори з великою вагою без реальної причини
    int ftotal = 0;
    int fcount = min(nf, 3);
    for (int i = 0; i < fcount; i++) ftotal += factors[i].weight;
    if (ftotal == 0) ftotal = 1;
    String factorsJson = "[";
    for (int i = 0; i < fcount; i++) {
      int pct = (factors[i].weight*100)/ftotal;
      if (i > 0) factorsJson += ",";
      factorsJson += "{\"n\":\"" + String(factors[i].name) + "\",\"p\":" + String(pct) + ",\"neg\":" + String(factors[i].negative?"true":"false") + "}";
    }
    factorsJson += "]";
    String json = "{";
    json += "\"hint\":\"" + hint + "\",";
    json += "\"reason\":\"" + reason + "\",";
    json += "\"dir\":\"" + direction + "\",";
    json += "\"spawnNote\":\"" + spawnNote + "\",";
    json += "\"factors\":" + factorsJson;
    json += "}";
    webServer.send(200, "application/json", json);
  });

  // WiFi дані для вкладки
  webServer.on("/wifidata", [&]() {
    String json = "{";
    json += "\"city\":\"" + String(cityName) + "\",";
    json += "\"lat\":"  + String(cityLat, 4) + ",";
    json += "\"lon\":"  + String(cityLon, 4) + ",";
    json += "\"forecastTs\":" + String(forecastTimestamp) + ",";
    json += "\"forecastValid\":" + String(forecastValid ? "true" : "false") + ",";
    json += "\"staConnected\":" + String(staConnected ? "true" : "false") + ",";
    // Слоти координат
    json += "\"coordLatA\":" + String(coordLatA, 4) + ",";
    json += "\"coordLonA\":" + String(coordLonA, 4) + ",";
    json += "\"coordLatB\":" + String(coordLatB, 4) + ",";
    json += "\"coordLonB\":" + String(coordLonB, 4) + ",";
    json += "\"coordSlot\":" + String(coordActiveSlot) + ",";
    // Слоти тиску
    json += "\"pressSlotA\":" + String(pressSlotA, 1) + ",";
    json += "\"pressSlotB\":" + String(pressSlotB, 1) + ",";
    json += "\"pressSlot\":" + String(pressActiveSlot) + ",";
    if (staConnected) {
      json += "\"connectedSsid\":\"" + WiFi.SSID() + "\",";
      json += "\"staIp\":\"" + WiFi.localIP().toString() + "\",";
    } else {
      json += "\"connectedSsid\":\"\",";
      json += "\"staIp\":\"\",";
    }
    json += "\"nets\":[";
    for (byte i = 0; i < wifiNetCount; i++) {
      if (i) json += ",";
      json += "\"" + String(wifiNets[i].ssid) + "\"";
    }
    json += "]";
    json += "}";
    webServer.send(200, "application/json", json);
  });
  webServer.on("/setcoords", [&]() {
    if (!webServer.hasArg("lat") || !webServer.hasArg("lon")) {
      webServer.send(400, "text/plain", "Missing lat/lon"); return;
    }
    float lat = webServer.arg("lat").toFloat();
    float lon = webServer.arg("lon").toFloat();
    if (lat < -90 || lat > 90 || lon < -180 || lon > 180) {
      webServer.send(200, "text/plain", "Bad range"); return;
    }
    byte slot = webServer.hasArg("slot") ? (byte)webServer.arg("slot").toInt() : coordActiveSlot;
    if (slot > 1) slot = 0;
    if (slot == 0) { coordLatA = lat; coordLonA = lon; }
    else           { coordLatB = lat; coordLonB = lon; }
    // Якщо зберігаємо активний слот — оновлюємо cityLat/cityLon
    if (slot == coordActiveSlot) { cityLat = lat; cityLon = lon; }
    saveWifiNets();
    webServer.send(200, "text/plain", "OK");
  });

  // Перемикання активного слота координат
  webServer.on("/coordslot", [&]() {
    if (!webServer.hasArg("slot")) { webServer.send(400); return; }
    byte s = (byte)webServer.arg("slot").toInt();
    if (s > 1) { webServer.send(400, "text/plain", "Bad"); return; }
    coordActiveSlot = s;
    cityLat = (s == 0) ? coordLatA : coordLatB;
    cityLon = (s == 0) ? coordLonA : coordLonB;
    saveWifiNets();
    webServer.send(200, "text/plain", "OK");
  });

  // Додати мережу
  webServer.on("/addnet", [&]() {
    if (!webServer.hasArg("ssid")) { webServer.send(400); return; }
    if (wifiNetCount >= MAX_WIFI_NETS) { webServer.send(200, "text/plain", "FULL"); return; }
    String ssid = webServer.arg("ssid");
    String pass = webServer.arg("pass");
    // Перевіряємо чи вже є така мережа
    for (byte i = 0; i < wifiNetCount; i++) {
      if (String(wifiNets[i].ssid) == ssid) {
        strncpy(wifiNets[i].pass, pass.c_str(), sizeof(wifiNets[i].pass)-1);
        saveWifiNets();
        webServer.send(200, "text/plain", "OK");
        return;
      }
    }
    strncpy(wifiNets[wifiNetCount].ssid, ssid.c_str(), sizeof(wifiNets[0].ssid)-1);
    strncpy(wifiNets[wifiNetCount].pass, pass.c_str(), sizeof(wifiNets[0].pass)-1);
    wifiNetCount++;
    saveWifiNets();
    // Одразу пробуємо підключитись до нової мережі неблокуюче
    if (!staConnected) {
      WiFi.mode(WIFI_AP_STA);
      WiFi.begin(ssid.c_str(), pass.c_str());
      wifiConnectStart = millis();
      wifiConnecting = true;
      wifiConnectIdx = wifiNetCount - 1;
      Serial.print("WiFi try (addnet): "); Serial.println(ssid);
    }
    webServer.send(200, "text/plain", "OK");
  });

  // Видалити мережу
  webServer.on("/removenet", [&]() {
    if (!webServer.hasArg("idx")) { webServer.send(400); return; }
    int idx = webServer.arg("idx").toInt();
    if (idx < 0 || idx >= wifiNetCount) { webServer.send(400); return; }
    for (int i = idx; i < wifiNetCount - 1; i++) wifiNets[i] = wifiNets[i+1];
    wifiNetCount--;
    saveWifiNets();
    webServer.send(200, "text/plain", "OK");
  });

  // Ручна синхронізація прогнозу — повертає відразу "QUEUED", не блокує веб-сервер.
  // JS опитує /syncstatus кожну секунду щоб дізнатись результат.
  webServer.on("/syncforecast", [&]() {
    if (cityLat == 0.0f) { webServer.send(200, "text/plain", "No city"); return; }
    if (!staConnected)   { webServer.send(200, "text/plain", "No WiFi"); return; }
    if (forecastSyncing || fetchTaskHandle != NULL) {
      webServer.send(200, "text/plain", "BUSY"); return;
    }
    Serial.println("Manual forecast sync via web (async)");
    manualSyncDone = false;
    manualSyncOk   = false;
    xTaskCreatePinnedToCore([](void*){
      bool r = fetchForecast();
      manualSyncOk   = r;
      manualSyncDone = true;
      fetchTaskHandle = NULL;
      vTaskDelete(NULL);
    }, "fetchFC", 8192, NULL, 1, &fetchTaskHandle, 0);
    webServer.send(200, "text/plain", "QUEUED");
  });

  // Статус ручної синхронізації (JS polls цей endpoint кожну секунду)
  webServer.on("/syncstatus", [&]() {
    if (forecastSyncing)        { webServer.send(200, "text/plain", "SYNCING"); return; }
    if (!manualSyncDone)        { webServer.send(200, "text/plain", "IDLE");    return; }
    // Якщо fetchForecast повернув false але дані є — вважаємо успіхом
    webServer.send(200, "text/plain", (manualSyncOk || forecastValid) ? "OK" : "Error");
  });

  // Ручна синхронізація сходу/заходу сонця — асинхронний виклик через таск.
  // JS опитує /sunsyncstatus щоб отримати результат.
  webServer.on("/syncsun", [&]() {
    if (cityLat == 0.0f) { webServer.send(200, "text/plain", "No city"); return; }
    if (!staConnected)   { webServer.send(200, "text/plain", "No WiFi"); return; }
    if (sunSyncing)      { webServer.send(200, "text/plain", "BUSY"); return; }
    Serial.println("Manual sunrise sync via web (async)");
    sunSyncDone = false;
    sunSyncOk   = false;
    sunSyncing  = true;
    xTaskCreatePinnedToCore([](void*){
      bool r = fetchSunTimes();
      sunSyncOk   = r;
      sunSyncDone = true;
      sunSyncing  = false;
      vTaskDelete(NULL);
    }, "sunSync", 6144, NULL, 1, NULL, 0);
    webServer.send(200, "text/plain", "QUEUED");
  });

  // Статус асинхронної синхронізації sunrise
  webServer.on("/sunsyncstatus", [&]() {
    if (sunSyncing)   { webServer.send(200, "text/plain", "SYNCING"); return; }
    if (!sunSyncDone) { webServer.send(200, "text/plain", "IDLE");    return; }
    webServer.send(200, "text/plain", sunSyncOk ? "OK" : "Error");
  });

  // Ручна синхронізація часу через NTP (кнопка в веб-меню)
  webServer.on("/synctime", [&]() {
    if (!staConnected) {
      webServer.send(200, "application/json", "{\"ok\":false,\"msg\":\"No WiFi\"}");
      return;
    }
    syncNTP();
    // Повертаємо поточний час після синхронізації
    char buf[64];
    snprintf(buf, sizeof(buf),
      "{\"ok\":true,\"h\":%d,\"m\":%d,\"s\":%d,\"tz\":%d}",
      hrs, mins, secs, (int)(getUtcOffset()/3600));
    webServer.send(200, "application/json", buf);
    Serial.println("Manual NTP sync done via web");
  });

  // Підказка базового тиску з Open-Meteo — тільки повертає значення, НЕ зберігає.
  // Юзер сам вирішує вставляти в поле чи ні.
  webServer.on("/hintbasepress", [&]() {
    if (!staConnected) { webServer.send(200, "text/plain", "No WiFi"); return; }
    if (cityLat == 0.0f) { webServer.send(200, "text/plain", "No coords"); return; }
    float bp = fetchBasePress();
    if (bp < 680 || bp > 800) { webServer.send(200, "text/plain", "Error"); return; }
    webServer.send(200, "text/plain", String(bp, 1));
  });

  // Дані прогнозу для вкладки (перші 7 днів × 24 год)
  webServer.on("/forecastdata", [&]() {
    // Рахуємо скільки реально ненульових годин є в масиві
    // (після forecastScroll кінець масиву може бути нулями)
    int validHours = 0;
    if (forecastValid) {
      for (int i = 0; i < FORECAST_HOURS; i++) {
        if (forecast[i].pressure > 0) validHours = i + 1;
      }
    }

    String json = "{";
    json += "\"valid\":" + String(forecastValid ? "true" : "false") + ",";
    json += "\"ts\":" + String(forecastTimestamp) + ",";
    json += "\"validHours\":" + String(validHours) + ",";
    // UTC зсув для JS: щоб правильно групувати дні (часовий пояс браузера ≠ ESP32)
    json += "\"utcOffsetSec\":" + String(getUtcOffset()) + ",";
    // Метадані для JS: прогноз показується з 04:00 до 00:00 (21 година)
    // Дні не видаляються поки не пройшли повністю
    json += "\"displayStartHour\":4,";   // відображення з 4:00
    json += "\"displayEndHour\":24,";    // до 00:00 наступного дня (24 = включно 23:00)
    // Денний кеш — стабільний прогноз на поточний день по годинах (не зникає між оновленнями)
    json += "\"dayCache\":{";
    json += "\"valid\":" + String(dayCache.valid ? "true" : "false") + ",";
    json += "\"ts\":" + String(dayCache.dayTimestamp) + ",";
    json += "\"hours\":[";
    for (int h = 0; h < 24; h++) {
      if (h) json += ",";
      json += "{\"t\":" + String(dayCache.valid ? (int)dayCache.temp[h] : 0) + ",";
      json += "\"p\":"   + String(dayCache.valid ? (int)dayCache.pressure[h] : 0) + ",";
      json += "\"pop\":" + String(dayCache.valid ? (int)dayCache.pop[h] : 0) + ",";
      json += "\"wid\":" + String(dayCache.valid ? (int)dayCache.wid[h] : 0) + ",";
      json += "\"h\":"   + String(dayCache.valid ? (int)dayCache.hum[h] : 0) + ",";
      json += "\"w\":"   + String(dayCache.valid ? (int)dayCache.wind[h] : 0) + ",";
      json += "\"c\":"   + String(dayCache.valid ? (int)dayCache.cloud[h] : 0) + ",";
      json += "\"wd\":"  + String(dayCache.valid ? (int)dayCache.windDir[h] : 0) + "}";
    }
    json += "]},";
    json += "\"hours\":[";
    for (int i = 0; i < validHours; i++) {
      if (i) json += ",";
      json += "{\"t\":" + String(forecast[i].temp)     + ",";
      json += "\"p\":"  + String(forecast[i].pressure) + ",";
      json += "\"pop\":" + String(forecast[i].pop)     + ",";
      json += "\"wid\":" + String(forecast[i].wid)     + ",";
      json += "\"h\":"   + String(forecast[i].hum)     + ",";
      json += "\"w\":"   + String(forecast[i].wind)    + ",";
      json += "\"c\":"   + String(forecast[i].cloud)   + ",";
      json += "\"wd\":"  + String(forecast[i].windDir) + "}";
    }
    // Сонячні дані для 7 днів
    json += "],\"sunTimes\":[";
    for (int i = 0; i < 7; i++) {
      if (i) json += ",";
      // Формуємо рядок дати з sunDayTs (UTC unix) + utcOff = local midnight
      // dayTs (local midnight) зберігається як sunDayTs + utcOff
      // щоб отримати дату: беремо sunDayTs[i] + 2*utcOff і gmtime_r
      // бо sunDayTs = dayTs - utcOff, dayTs = local_midnight_unix
      // для отримання дати: dayTs + utcOff -> gmtime_r дає local date
      int32_t utcOff_d = getUtcOffset();
      uint32_t localMid = (uint32_t)((int64_t)dayCache.sunDayTs[i] + 2*utcOff_d);
      time_t lm = (time_t)localMid;
      struct tm tmD; gmtime_r(&lm, &tmD);
      char dateBuf[12];
      snprintf(dateBuf, sizeof(dateBuf), "%04d-%02d-%02d",
               tmD.tm_year+1900, tmD.tm_mon+1, tmD.tm_mday);
      json += "{\"dayTs\":";
      json += String(dayCache.sunDayTs[i]);
      json += ",\"date\":\"";
      json += dateBuf;
      json += "\",\"rise\":";
      json += String(dayCache.sunriseMin[i] == 0xFFFF ? -1 : (int)dayCache.sunriseMin[i]);
      json += ",\"set\":";
      json += String(dayCache.sunsetMin[i]  == 0xFFFF ? -1 : (int)dayCache.sunsetMin[i]);
      json += "}";
    }
    json += "]}";
    webServer.send(200, "application/json", json);
  });

  // Підключитись до збереженої мережі за індексом
  webServer.on("/connectnet", [&]() {
    if (!webServer.hasArg("idx")) { webServer.send(400, "text/plain", "Bad"); return; }
    int idx = webServer.arg("idx").toInt();
    if (idx < 0 || idx >= wifiNetCount) { webServer.send(400, "text/plain", "Bad idx"); return; }
    // Якщо вже підключені до цієї мережі
    if (staConnected && WiFi.SSID() == String(wifiNets[idx].ssid)) {
      webServer.send(200, "text/plain", "CONNECTED"); return;
    }
    WiFi.mode(apActive ? WIFI_AP_STA : WIFI_STA);
    WiFi.begin(wifiNets[idx].ssid, wifiNets[idx].pass);
    wifiConnectStart = millis();
    wifiConnecting = true;
    wifiConnectIdx = idx;
    Serial.print("WiFi connect by request: "); Serial.println(wifiNets[idx].ssid);
    webServer.send(200, "text/plain", "TRYING");
  });
  // Сканування WiFi мереж
  webServer.on("/scanwifi", [&]() {
    int n = WiFi.scanNetworks(false, false, false, 300);
    String json = "[";
    for (int i = 0; i < n; i++) {
      if (i) json += ",";
      String s = WiFi.SSID(i);
      s.replace("\\", "\\\\");
      s.replace("\"", "\\\"");
      json += "{\"ssid\":\"" + s + "\",\"rssi\":" + String(WiFi.RSSI(i)) + "}";
    }
    json += "]";
    WiFi.scanDelete();
    webServer.send(200, "application/json", json);
  });

  // Перемикання активного слота тиску
  webServer.on("/pressslot", [&]() {
    if (!webServer.hasArg("slot")) { webServer.send(400); return; }
    byte s = (byte)webServer.arg("slot").toInt();
    if (s > 1) { webServer.send(400, "text/plain", "Bad slot"); return; }
    pressActiveSlot = s;
    SEA_PRESS_MM = (s == 0) ? pressSlotA : pressSlotB;
    resetRuntimePressureState();
    prefs.begin("fish", false);
    prefs.putUChar("pressSlot", pressActiveSlot);
    prefs.end();
    webServer.send(200, "text/plain", "OK");
  });

  // Зберегти значення слота тиску
  webServer.on("/setpressslot", [&]() {
    if (!webServer.hasArg("slot") || !webServer.hasArg("val")) { webServer.send(400); return; }
    byte s = (byte)webServer.arg("slot").toInt();
    float val = webServer.arg("val").toFloat();
    if (s > 1 || !((val == 0.0f) || (val >= 680 && val <= 800))) { webServer.send(400, "text/plain", "Bad"); return; }
    if (s == 0) pressSlotA = val; else pressSlotB = val;
    if (pressActiveSlot == s) SEA_PRESS_MM = val;
    if (pressActiveSlot == s) resetRuntimePressureState();
    prefs.begin("fish", false);
    prefs.putFloat("pressA", pressSlotA);
    prefs.putFloat("pressB", pressSlotB);
    prefs.putFloat("basePress", SEA_PRESS_MM); // сумісність
    prefs.end();
    webServer.send(200, "text/plain", "OK");
  });

  // Часовий пояс
  webServer.on("/settz", [&]() {
    if (!webServer.hasArg("mode")) { webServer.send(400); return; }
    byte m = (byte)webServer.arg("mode").toInt();
    if (m > 2) { webServer.send(400, "text/plain", "Bad mode"); return; }
    tzMode = m;
    saveSettings();
    // Перезастосовуємо NTP з новим офсетом якщо підключені
    if (staConnected) syncNTP();
    webServer.send(200, "text/plain", "OK");
  });

  webServer.on("/settings", [&]() {
    bool ok = false;
    if (webServer.hasArg("ft")) {
      byte ft = (byte)webServer.arg("ft").toInt();
      if (ft <= 5) { fishType = ft; ok = true; }
    }
    if (webServer.hasArg("ut")) {
      useTime = (webServer.arg("ut").toInt() == 1);
      ok = true;
    }
    if (webServer.hasArg("us")) {
      useSpawn = (webServer.arg("us").toInt() == 1);
      ok = true;
    }
    if (webServer.hasArg("um")) {
      useMoon = (webServer.arg("um").toInt() == 1);
      ok = true;
    }
    if (webServer.hasArg("wt")) {
      byte wt = (byte)webServer.arg("wt").toInt();
      if (wt <= 1) { waterType = wt; ok = true; }
    }
    if (ok) {
      saveSettings();
      webServer.send(200, "text/plain", "OK");
    } else {
      webServer.send(400, "text/plain", "Bad value");
    }
  });

  webServer.on("/factoryreset", [&]() {
    prefs.begin("fish", false); prefs.clear(); prefs.end();
    prefs.begin("wifi", false); prefs.clear(); prefs.end();
    prefs.begin("fcast", false); prefs.clear(); prefs.end();
    factoryResetRuntime();
    if (mode == 0) {
      lcd.clear();
      loadClock();
      drawClock(hrs, mins, 0, 0, true);
      drawData();
      drawSensors();
    }
    webServer.send(200, "text/plain", "OK");
  });

  // Обробник для невідомих запитів і fallback для помилок JS
  webServer.onNotFound([&]() {
    String path = webServer.uri();
    Serial.printf("WebServer 404: %s\n", path.c_str());
    if (path.endsWith(".json") || webServer.hasHeader("Accept") &&
        webServer.header("Accept").indexOf("application/json") >= 0) {
      webServer.send(404, "application/json", "{\"error\":\"not found\"}");
    } else {
      webServer.send(404, "text/plain", "Not found: " + path);
    }
  });
}

// ------------------------- КНОПКА -------------------------
void goHome() {
  mode = 0;
  lcd.clear();
  loadClock();
  drawClock(hrs, mins, 0, 0, true);
  drawData();
  drawSensors();
  drawApBadge();
}

void modesTick() {
  bool btnNow = digitalRead(BTN_PIN);

  // Натиснули
  if (btnNow && !btnPrev) btnPressTime = millis();

  static bool longFired = false;
  uint32_t held = millis() - btnPressTime;

  // Затиск 3 сек на головній → показує WiFi екран
  // Якщо є роутер — просто показуємо інфо (AP не потрібна)
  // Якщо немає роутера — вмикає/вимикає AP
  if (btnNow && !longFired && mode == 0 && held >= 3000) {
    longFired = true;
    if (staConnected) {
      // Є роутер — просто показуємо інфо екран, AP не чіпаємо
      mode = 5;
      lcd.clear();
      drawWifiScreen();
    } else if (!apActive) {
      startAP();
      mode = 5;
      lcd.clear();
      drawWifiScreen();
    } else {
      stopAP();
      goHome();
    }
  }

  // Затиск 1 сек на графіках → головна
  if (btnNow && !longFired && ((mode >= 1 && mode <= 4) || mode == 6) && held >= 1000) {
    longFired = true;
    goHome();
  }

  // Відпустили
  if (!btnNow && btnPrev) {
    if (!longFired && held < 800) {
      if (mode == 5) {
        // Клік на WiFi екрані → повернення на головну, AP продовжує працювати
        goHome();
      } else if (mode == 0) {
        mode = 1;
        lcd.clear();
        loadPlot();
        redrawPlot();
      } else {
        if (mode == 4) mode = 6;
        else if (mode == 6) mode = 0;
        else mode++;
        lcd.clear();
        if (mode == 0) {
          goHome();
        } else {
          loadPlot();
          redrawPlot();
        }
      }
    }
    longFired = false;
  }

  btnPrev = btnNow;
}

// ------------------------- ГОДИННИК -----------------------
void loadClock() {
  lcd.createChar(0, LT);
  lcd.createChar(1, UB);
  lcd.createChar(2, RT);
  lcd.createChar(3, LL);
  lcd.createChar(4, LB);
  lcd.createChar(5, LR);
  lcd.createChar(6, UMB);
  lcd.createChar(7, LMB);
}

void loadPlot() {
  lcd.createChar(0, row8);
  lcd.createChar(1, row1);
  lcd.createChar(2, row2);
  lcd.createChar(3, row3);
  lcd.createChar(4, row4);
  lcd.createChar(5, row5);
  lcd.createChar(6, row6);
  lcd.createChar(7, row7);
}

void drawDig(byte dig, byte x, byte y) {
  switch (dig) {
    case 0:
      lcd.setCursor(x,y);   lcd.write(0); lcd.write(1); lcd.write(2);
      lcd.setCursor(x,y+1); lcd.write(3); lcd.write(4); lcd.write(5); break;
    case 1:
      lcd.setCursor(x+1,y);   lcd.write(1); lcd.write(2);
      lcd.setCursor(x+2,y+1); lcd.write(5); break;
    case 2:
      lcd.setCursor(x,y);   lcd.write(6); lcd.write(6); lcd.write(2);
      lcd.setCursor(x,y+1); lcd.write(3); lcd.write(7); lcd.write(7); break;
    case 3:
      lcd.setCursor(x,y);   lcd.write(6); lcd.write(6); lcd.write(2);
      lcd.setCursor(x,y+1); lcd.write(7); lcd.write(7); lcd.write(5); break;
    case 4:
      lcd.setCursor(x,y);   lcd.write(3); lcd.write(4); lcd.write(2);
      lcd.setCursor(x+2,y+1); lcd.write(5); break;
    case 5:
      lcd.setCursor(x,y);   lcd.write(0); lcd.write(6); lcd.write(6);
      lcd.setCursor(x,y+1); lcd.write(7); lcd.write(7); lcd.write(5); break;
    case 6:
      lcd.setCursor(x,y);   lcd.write(0); lcd.write(6); lcd.write(6);
      lcd.setCursor(x,y+1); lcd.write(3); lcd.write(7); lcd.write(5); break;
    case 7:
      lcd.setCursor(x,y);   lcd.write(1); lcd.write(1); lcd.write(2);
      lcd.setCursor(x+1,y+1); lcd.write(0); break;
    case 8:
      lcd.setCursor(x,y);   lcd.write(0); lcd.write(6); lcd.write(2);
      lcd.setCursor(x,y+1); lcd.write(3); lcd.write(7); lcd.write(5); break;
    case 9:
      lcd.setCursor(x,y);   lcd.write(0); lcd.write(6); lcd.write(2);
      lcd.setCursor(x+1,y+1); lcd.write(4); lcd.write(5); break;
    case 10:
      lcd.setCursor(x,y);   lcd.print("   ");
      lcd.setCursor(x,y+1); lcd.print("   "); break;
  }
}

void drawdots(byte x, byte y, bool state) {
  byte code = state ? 165 : 32;
  lcd.setCursor(x, y);   lcd.write(code);
  lcd.setCursor(x, y+1); lcd.write(code);
}

void drawClock(byte hours, byte minutes, byte x, byte y, bool dotState) {
  lcd.setCursor(x,   y);   lcd.print("               ");
  lcd.setCursor(x, y+1);   lcd.print("               ");
  if (hours/10 == 0) drawDig(10, x, y);
  else               drawDig(hours/10, x, y);
  drawDig(hours%10,   x+4,  y);
  drawDig(minutes/10, x+8,  y);
  drawDig(minutes%10, x+12, y);
}

void drawData() {
  lcd.setCursor(15, 0);
  if (now.day() < 10) lcd.print('0');
  lcd.print(now.day());
  lcd.print('.');
  if (now.month() < 10) lcd.print('0');
  lcd.print(now.month());

  lcd.setCursor(16, 1);
  if (DISP_MODE == 0) {
    lcd.print(now.year());
  } else if (DISP_MODE == 1) {
    lcd.print(dayNames[now.dayOfTheWeek()]);
  } else {
    if (secs < 10) lcd.print('0');
    lcd.print(secs);
    lcd.print("  ");
  }
}

// ------------------------- ДАТЧИКИ ------------------------
void readSensors() {
  bme.takeForcedMeasurement();
  dispTemp = bme.readTemperature();
  dispHum  = (byte)bme.readHumidity();
  dispPres = bme.readPressure() * 0.00750062f;
}

void drawSensors() {
  char buf[21];

  if (!basePressureSet()) {
    lcd.setCursor(0, 2);
    lcd.print("SET BASE PRESSURE ");
    lcd.setCursor(0, 3);
    lcd.print("HOLD 3S WIFI SETUP");
    drawApBadge();
    return;
  }

  // Рядок 2: фіксований layout 20 символів
  // [0-4]=темп [5]=° [6-8]=вол% [9]= [10-14]=K:xxx [15-19]=S:xxx
  // Температура і вологість — з датчика BME280 (кімнатні)
  lcd.setCursor(0, 2);
  dtostrf(dispTemp, 4, 1, buf);
  lcd.print(buf);
  lcd.write(223);                    // °
  if (dispHum < 10) lcd.print(' '); // вирівнювання
  lcd.print(dispHum);
  lcd.print('%');
  lcd.print(' ');

  byte score = calcFishScore();
  if      (score == 255) lcd.print("K:...");
  else if (score == 0)   lcd.print("K:Bad");
  else if (score == 1)   lcd.print("K:50%");
  else if (score == 2)   lcd.print("K:Ok ");
  else                   lcd.print("K:Gr!");

  // weatherCloudy — з реального прогнозу (WMO: 0=ясно, 1-2=частково, 3+=хмарно)
  bool weatherCloudy = false;
  int fcIdx = forecastCurrentIdx();
  if (forecastValid && fcIdx >= 0) {
    weatherCloudy = (forecast[fcIdx].wid >= 3 || forecast[fcIdx].cloud >= 60);
  }

  byte mo = rtc.now().month();
  byte season = getSeason();

  // --- Снасті: літня логіка ---
  // Дощ або вітер з прогнозу
  bool fcRainNow = false;
  bool fcHot     = false;   // спека: >26°C
  float fcTemp   = 0.0f;
  uint8_t fcWind = 0;
  if (forecastValid && fcIdx >= 0) {
    fcRainNow = (forecast[fcIdx].wid >= 51 && forecast[fcIdx].wid <= 99) || forecast[fcIdx].pop > 60;
    fcTemp    = forecast[fcIdx].temp;
    fcHot     = (fcTemp > 26.0f);
    fcWind    = forecast[fcIdx].wind;
  }
  byte h = (byte)hrs;
  bool morningEvening = (h >= 5 && h <= 9) || (h >= 18 && h <= 22); // ранок 5-9, вечір 18-22

  bool highPressTackle = basePressureSet() && (dispPres - SEA_PRESS_MM) > 5.0f; // тиск суттєво вищий норми
  bool lowPressTackle  = lowPressTackleColumn();            // риба в товщі при низькому/новому тиску
  bool strongWindTackle = (fcWind >= 6);                    // >=6 м/с — поплавок зносить

  const char* tackle;
  if (score == 255) {
    tackle = "S:...";

  } else if (score == 0) {
    // BAD кльов
    if (highPressTackle || strongWindTackle) {
      // Тиск давить вниз або хвиля → риба на дні → донка
      tackle = "S:D  ";
    } else if (lowPressTackle || fcRainNow) {
      // Низький тиск/дощ → риба в пів-воді, поплавок
      tackle = "S:P  ";
    } else {
      // Нейтральна пасивна ситуація → донка (лежить тихо)
      tackle = "S:D  ";
    }

  } else if (score == 1) {
    // 50/50
    if (strongWindTackle || highPressTackle) {
      tackle = "S:D  "; // вітер або тиск → донка надійніша
    } else if (fcRainNow && !strongWindTackle) {
      tackle = "S:P  "; // дощик без вітру → риба в пів-воді
    } else {
      tackle = "S:D&P"; // нейтральні умови → обидві
    }

  } else {
    // score 2 або 3 — Ok або Gr!
    if (strongWindTackle) {
      // Сильний вітер — поплавок зносить → тільки донка
      tackle = "S:D  ";
    } else if (highPressTackle) {
      // Тиск нещодавно зріс → риба притиснута до дна → донка
      tackle = "S:D  ";
    } else if (season == 3) {
      // ===== ЛІТО =====
      if (morningEvening) {
        // Ранок 5-9 і вечір 18-22 — обидві: і поплавок і донка
        tackle = "S:D&P";
      } else {
        // День 10-17
        if (fcHot && !weatherCloudy && !fcRainNow) {
          // Сонячна спека без хмар і дощу: риба виходить до поверхні
          // Поплавок краще — насадка повільно падає під ніс
          tackle = "S:P  ";
        } else {
          // Хмарно або дощ вдень, або не дуже спекотно — обидві
          tackle = "S:D&P";
        }
      }
    } else {
      // Весна / Осінь / Зима
      bool dayTime = (h >= 7 && h <= 20);
      if (!dayTime) {
        tackle = "S:D  "; // ніч — тільки донка
      } else if (fcRainNow && !strongWindTackle) {
        tackle = "S:P  "; // дощ без вітру — риба в пів-воді
      } else {
        tackle = "S:D&P"; // день, норм. погода — обидві
      }
    }
  }
  lcd.setCursor(15, 2);
  lcd.print(tackle);

  // Рядок 3: тиск, дощ, висота — позиції 0-17, значок на 18-19
  {
    char presStr[7];
    dtostrf(dispPres, 5, 1, presStr);
    int rain3 = constrain(dispRain, 0, 99);
    int alt   = (int)((STD_SEA_PRESS_MM - dispPres) * 10.5f);

    // Рахуємо скільки символів займе рядок до висоти
    // "PPP.P" + "mm r:" + дощ + "% "
    int pos = 5 + 5 + (rain3 >= 10 ? 2 : 1) + 2; // позиція курсора перед висотою
    (void)pos; // використовується лише для підрахунку space який не потрібен

    // Буфер 18 символів + \0, завжди заповнений пробілами щоб не лишати сміття
    char row3[19];
    memset(row3, ' ', 18);
    row3[18] = '\0';
    memcpy(row3, presStr, 5);
    row3[5]='m'; row3[6]='m'; row3[7]=' '; row3[8]='r'; row3[9]=':';
    if (rain3 >= 10) {
      row3[10]='0'+rain3/10; row3[11]='0'+rain3%10; row3[12]='%'; row3[13]=' ';
    } else {
      row3[10]='0'+rain3; row3[11]='%'; row3[12]=' '; row3[13]=' ';
    }
    char altStr[6];
    int altLen = snprintf(altStr, sizeof(altStr), "%dm", alt);
    if (altLen > 4) altLen = 4;
    for (int i = 0; i < altLen; i++) row3[14+i] = altStr[i];
    lcd.setCursor(0, 3);
    lcd.print(row3);
  }
  // Відновлюємо WiFi значок на позиціях 18-19
  drawApBadge();
}

// ------------------------- ГРАФІКИ -----------------------
void drawPlot(byte pos, byte row, byte width, byte height,
              int min_val, int max_val, int *plot_array, const char* label) {
  bool isPressure = (label[0] == 'p');  // "p hr" або "p dy" — графік тиску
  int max_value = -32000, min_value = 32000;
  bool hasValue = false;
  for (byte i = 0; i < 15; i++) {
    if (isPressure && plot_array[i] <= 0) continue;
    if (plot_array[i] > max_value) max_value = plot_array[i];
    if (plot_array[i] < min_value) min_value = plot_array[i];
    hasValue = true;
  }
  if (!hasValue) {
    lcd.setCursor(0, 0); lcd.print("GRAPH FORMING    ");
    lcd.setCursor(0, 1); lcd.print(label);
    lcd.setCursor(0, 2); lcd.print("WAIT FOR DATA    ");
    lcd.setCursor(0, 3); lcd.print("                ");
    return;
  }

  // Для тиску: значення в масиві ×10 (0.1 мм). Авто-масштаб з відступом ±5 (=0.5 мм)
  // щоб мікро-коливання 0.1-0.2 мм були видні
  if (isPressure) {
    int margin = 5;  // ±0.5 мм
    int mid  = (max_value + min_value) / 2;
    int half = max((max_value - min_value) / 2 + margin, 5);
    min_val = mid - half;
    max_val = mid + half;
    // Клемп від динамічних меж (SEA_PRESS_MM ±30 мм ×10)
    if (min_val < pressPlotMin()) min_val = pressPlotMin();
    if (max_val > pressPlotMax()) max_val = pressPlotMax();
  }

  // Вивід значень: тиск ділимо на 10 щоб показати мм.рт
  if (isPressure) {
    int current_value = plot_array[14];
    if (current_value <= 0) {
      for (int i = 14; i >= 0; i--) {
        if (plot_array[i] > 0) { current_value = plot_array[i]; break; }
      }
    }
    lcd.setCursor(16, 0); lcd.print(max_value / 10.0f, 1); lcd.print(" ");
    lcd.setCursor(16, 1); lcd.print(label);
    lcd.setCursor(16, 2); lcd.print(current_value / 10.0f, 1); lcd.print(" ");
    lcd.setCursor(16, 3); lcd.print(min_value / 10.0f, 1); lcd.print(" ");
  } else {
    lcd.setCursor(16, 0); lcd.print(max_value);  lcd.print("  ");
    lcd.setCursor(16, 1); lcd.print(label);
    lcd.setCursor(16, 2); lcd.print(plot_array[14]); lcd.print("  ");
    lcd.setCursor(16, 3); lcd.print(min_value);  lcd.print("  ");
  }

  for (byte i = 0; i < width; i++) {
    if (isPressure && plot_array[i] <= 0) {
      for (byte n = 0; n < height; n++) {
        lcd.setCursor(i, row-n); lcd.write(16);
      }
      continue;
    }
    byte infill, fract;
    int range = max_val - min_val;
    if (range <= 0) range = 1; // захист від ділення на нуль
    if (plot_array[i] > min_val)
      infill = floor((float)(plot_array[i]-min_val)/range*height*10);
    else infill = 0;
    fract  = (float)(infill % 10)*8/10;
    infill = infill/10;
    for (byte n = 0; n < height; n++) {
      if (n < infill && infill > 0) {
        lcd.setCursor(i, row-n); lcd.write(0);
      }
      if (n >= infill) {
        lcd.setCursor(i, row-n);
        if (fract > 0) lcd.write(fract);
        else lcd.write(16);
        for (byte k = n+1; k < height; k++) {
          lcd.setCursor(i, row-k); lcd.write(16);
        }
        break;
      }
    }
  }
}

void drawBitePlot() {
  if (!basePressureSet() || !deltaReady) {
    lcd.setCursor(0, 0); lcd.print("BITE GRAPH       ");
    lcd.setCursor(0, 1); lcd.print("COLLECTING DATA  ");
    lcd.setCursor(0, 2); lcd.print("PRESS SAMPLES ");
    lcd.print(pressureSampleCount);
    lcd.print("/6");
    lcd.setCursor(0, 3); lcd.print("                ");
    return;
  }

  lcd.setCursor(16, 0); lcd.print("Grt ");
  lcd.setCursor(16, 1); lcd.print("fish");
  lcd.setCursor(16, 2);
  byte cur = (byte)constrain(fishHour[14], 0, 3);
  if      (cur == 0) lcd.print("Bad ");
  else if (cur == 1) lcd.print("50% ");
  else if (cur == 2) lcd.print("Good");
  else               lcd.print("Grt ");
  lcd.setCursor(16, 3); lcd.print("Bad ");

  for (byte i = 0; i < 15; i++) {
    int v = constrain(fishHour[i], 0, 3);
    byte barRows = (byte)(v + 1); // Bad теж видно як низький стовпець
    for (byte n = 0; n < 4; n++) {
      lcd.setCursor(i, 3 - n);
      lcd.write(n < barRows ? 0 : 16);
    }
  }
}

void redrawPlot() {
  lcd.clear();
  switch (mode) {
    case 1: drawPlot(0,3,15,4, TEMP_MIN,    TEMP_MAX,    (int*)tempDay,   "t dy"); break;
    case 2: drawPlot(0,3,15,4, HUM_MIN,     HUM_MAX,     (int*)humDay,    "h dy"); break;
    case 3: drawPlot(0,3,15,4, pressPlotMin(),pressPlotMax(),(int*)pressHour, "p hr"); break;
    case 4: drawPlot(0,3,15,4, pressPlotMin(),pressPlotMax(),(int*)pressDay,  "p dy"); break;
    case 6: drawBitePlot(); break;
  }
}

// ------------------------- ТАЙМЕРИ ГРАФІКІВ ---------------
void plotSensorsTick() {
  uint32_t ms = millis();

  // Кожні 2 хв — зсуваємо погодинний масив (15 точок = 30 хв)
  if (ms - hourPlotTimer_ms >= (uint32_t)2*60*1000) {
    hourPlotTimer_ms = ms;
    for (byte i = 0; i < 14; i++) {
      tempHour[i]  = tempHour[i+1];
      humHour[i]   = humHour[i+1];
      pressHour[i] = pressHour[i+1];
    }
    tempHour[14]  = (int)dispTemp;
    humHour[14]   = dispHum;
    pressHour[14] = (int)round(dispPres * 10.0f);  // 0.1 мм точність
  }

  // Кожні 30 хв — точка денного графіку (15 точок = ~7.5 год)
  if (ms - dayPlotTimer_ms >= (uint32_t)30*60*1000) {
    dayPlotTimer_ms = ms;
    long aT=0, aH=0, aP=0;
    byte cT=0, cH=0, cP=0;
    for (byte i=0; i<15; i++) {
      if (tempHour[i] != 0) { aT += tempHour[i]; cT++; }
      if (humHour[i]  != 0) { aH += humHour[i];  cH++; }
      if (pressHour[i] > 0) { aP += pressHour[i]; cP++; }
    }
    if (cT > 0 && cH > 0 && cP > 0) {
      aT/=cT; aH/=cH; aP/=cP;
      for (byte i=0; i<14; i++) {
        tempDay[i]  = tempDay[i+1];
        humDay[i]   = humDay[i+1];
        pressDay[i] = pressDay[i+1];
      }
      tempDay[14]  = (int)aT;
      humDay[14]   = (int)aH;
      pressDay[14] = (int)round((float)aP / 10.0f) * 10;  // середнє, але зберігаємо x10
    }
  }

  // Графік кльову — окремо: кожні 10 хв або при зміні значення
  // Перша точка зʼявляється одразу як тільки calcFishScore() != 255 (~30 хв)
  static byte     lastFishScore    = 255;
  static bool     fishFirstWritten = false;
  static uint32_t fishPlotTimer_ms = 0;
  {
    byte fsc = calcFishScore();
    if (fsc != 255) {
      bool firstWrite   = !fishFirstWritten;
      bool timeToUpdate = (ms - fishPlotTimer_ms >= (uint32_t)10*60*1000);
      bool scoreChanged = (fsc != lastFishScore);
      if (firstWrite || timeToUpdate || scoreChanged) {
        fishPlotTimer_ms = ms;
        lastFishScore    = fsc;
        fishFirstWritten = true;
        for (byte i = 0; i < 14; i++) fishHour[i] = fishHour[i+1];
        fishHour[14] = (int)fsc;
      }
    }
  }

  // Кожні 10 хв — прогноз дощу
  if (ms - predictTimer_ms >= (uint32_t)10*60*1000) {
    predictTimer_ms = ms;

    // --- Крок 1: середнє з 10 вимірів (~100 мс) → прибираємо миттєвий шум ---
    // readPressure() → float Па; int32_t: max 10×110000=1.1M << INT32_MAX
    int32_t averPress = 0;
    for (byte i=0; i<10; i++) {
      bme.takeForcedMeasurement();
      averPress += (int32_t)roundf(bme.readPressure());
      // takeForcedMeasurement сам чекає готовності (~10ms), delay не потрібен
    }
    averPress /= 10;

    // --- Крок 2: EMA (Exponential Moving Average) — фільтруємо мікроколивання ±0.1–0.3 мм ---
    // alpha=0.07: добре відфільтровує шум датчика, реальні стрибки (>3 мм за крок) — скидаємо фільтр.
    if (!smoothedPressInit) {
      smoothedPress     = (float)averPress;
      smoothedPressInit = true;
    } else {
      float diff_mm = fabsf((float)averPress - smoothedPress) * 0.00750062f;
      if (diff_mm > 3.0f) {
        // Справжній різкий стрибок — скидаємо EMA щоб не «запізнюватись»
        smoothedPress = (float)averPress;
      } else {
        smoothedPress = EMA_ALPHA * (float)averPress + (1.0f - EMA_ALPHA) * smoothedPress;
      }
    }
    int32_t filteredPress = (int32_t)roundf(smoothedPress);

    // --- Крок 3: заповнюємо кільцевий буфер згладженими значеннями ---
    if (pressureSampleCount < 6) {
      pressure_array[pressureSampleCount++] = filteredPress;
    } else {
      for (byte i=0; i<5; i++) pressure_array[i] = pressure_array[i+1];
      pressure_array[5] = filteredPress;
    }

    if (pressureSampleCount < 3) {
      delta = 0;
      deltaReady = false;
      dispRain = 0;
      updateFishLED();
      return;
    }

    // --- Крок 4: лінійна регресія по буферу ---
    byte usedSamples = pressureSampleCount < 6 ? pressureSampleCount : 6;

    sumX=0; sumY=0; sumX2=0; sumXY=0;
    // X = індекси 0..5 (не мілісекунди!), Y = тиск у Па — безпечно для int64_t
    for (int i=0; i<(int)usedSamples; i++) {
      sumX  += (int64_t)time_array[i];
      sumY  += (int64_t)pressure_array[i];
      sumX2 += (int64_t)time_array[i]*time_array[i];
      sumXY += (int64_t)time_array[i]*pressure_array[i];
    }
    a = (float)((int64_t)usedSamples*sumXY - sumX*sumY) / ((int64_t)usedSamples*sumX2 - sumX*sumX);
    delta = (int)(a * 6);

    // --- Крок 5: Deadband — ігноруємо зміни менше ±0.5 мм/год (природній фон для риби) ---
    // Старий поріг: 40 Па/год ≈ 0.30 мм/год — надто чутливий до шуму.
    // Новий поріг:  67 Па/год ≈ 0.50 мм/год — відповідає ТЗ.
    if (abs(delta) < 67) delta = 0;
    delta = constrain(delta, -1200, 1200);   // захист від збою буфера

    // Оригінальний розрахунок дощу AlexGyver:
    // delta > 0 — тиск росте → менше дощу, delta < 0 — падає → більше дощу
    dispRain = map(delta, -250, 250, 100, -100);
    dispRain = constrain(dispRain, 0, 100);  // без мінусів

    // Корекція dispRain прогнозним pop (відображається на екрані)
    // Логіка:
    //  1. Якщо розходження > 5% — м'яка корекція 20% різниці
    //  2. Якщо прогноз вказує на дощ (pop>60 або wid дощовий), а датчик каже "без дощу" (<30)
    //     АБО навпаки — агресивна корекція: зміщуємо на 60% різниці
    //  3. Якщо прогноз каже шторм/гроза (wid>=80) і датчик каже "немає дощу" (<40) —
    //     примусово встановлюємо мінімум 70% (прогноз інтернету надійніший за локальний тиск)
    if (forecastValid) {
      int idx = forecastCurrentIdx();
      if (idx >= 0) {
        int fcPop  = (int)forecast[idx].pop;
        uint8_t wid = forecast[idx].wid;

        // Чи вказує WMO код на дощ/шторм?
        bool fcRainy  = (wid >= 51 && wid <= 99) || fcPop > 60;
        bool fcStormy = (wid >= 80) || (wid >= 95);

        int diff = fcPop - dispRain;
        int absDiff = abs(diff);

        if (fcStormy && dispRain < 40) {
          // Прогноз: шторм/гроза, датчик думає що сухо — примусово коригуємо
          // Беремо максимум між поточним і 70%
          int target = max(70, (int)(dispRain + diff * 0.70f));
          dispRain = constrain(target, 0, 100);
        } else if (fcRainy && dispRain < 30) {
          // Прогноз: дощ, датчик: сухо — агресивна корекція 60%
          dispRain += (int)(diff * 0.60f);
          dispRain = constrain(dispRain, 0, 100);
        } else if (!fcRainy && dispRain > 70 && fcPop < 30) {
          // Прогноз: ясно, датчик: дощ — агресивна корекція в бік покращення
          dispRain += (int)(diff * 0.60f);
          dispRain = constrain(dispRain, 0, 100);
        } else if (absDiff > 5) {
          // Загальна м'яка корекція при будь-якому розходженні > 5%
          dispRain += (int)(diff * 0.20f);
          dispRain = constrain(dispRain, 0, 100);
        }
      }
    }

    deltaReady = (pressureSampleCount >= 3); // попередній прогноз з 3 зразків
    updateAdaptation();
    updateFishLED();
  }
}

// ------------------------- CLOCK TICK ---------------------
bool dotFlag = false;
void clockTick() {
  dotFlag = !dotFlag;
  if (dotFlag) {
    secs++;
    if (secs >= 60) {
      // Синхронізуємо з RTC кожну хвилину — усуває drift програмного таймера
      now = rtc.now();
      secs = now.second();
      byte newMins = now.minute();
      byte newHrs  = now.hour();
      bool hrsChanged = (newHrs != (byte)hrs);
      bool midnightNow = (hrsChanged && newHrs == 0); // щойно стало 00:00
      mins = newMins;
      hrs  = newHrs;
      if (mode == 0) drawClock(hrs, mins, 0, 0, true);
      if (hrsChanged && mode == 0) drawData();
      // Зсув масиву sunrise при переході доби — рівно о 00:00
      if (midnightNow && dayCache.sunDayTs[0] != 0) {
        // [0] вчорашній — зсуваємо на 1
        if (dayCache.sunDayTs[1] != 0) {
          for (int i = 0; i < 6; i++) {
            dayCache.sunriseMin[i] = dayCache.sunriseMin[i + 1];
            dayCache.sunsetMin[i]  = dayCache.sunsetMin[i + 1];
            dayCache.sunDayTs[i]   = dayCache.sunDayTs[i + 1];
          }
          dayCache.sunriseMin[6] = 0xFFFF;
          dayCache.sunsetMin[6]  = 0xFFFF;
          dayCache.sunDayTs[6]   = 0;
          saveSunTimes();
          Serial.printf("Midnight shift: today sunrise %02d:%02d\n",
            dayCache.sunriseMin[0]/60, dayCache.sunriseMin[0]%60);
        } else {
          // Завтра вже немає даних — скидаємо все (закінчились 7 днів)
          for (int i = 0; i < 7; i++) {
            dayCache.sunriseMin[i] = 0xFFFF;
            dayCache.sunsetMin[i]  = 0xFFFF;
            dayCache.sunDayTs[i]   = 0;
          }
          saveSunTimes();
          Serial.println("Sun times exhausted — cleared");
        }
      }
      // Щодобово о 00:00 якщо є WiFi — завантажуємо свіжі sunrise/sunset для всіх 7 днів
      if (midnightNow && staConnected && fetchTaskHandle == NULL && !forecastSyncing) {
        xTaskCreatePinnedToCore([](void*) {
          fetchSunTimes();
          vTaskDelete(NULL);
        }, "sunFetch", 6144, NULL, 1, NULL, 0);
        Serial.println("Midnight: scheduled daily sunrise refresh");
      }
    }
    if (DISP_MODE == 2 && mode == 0) {
      lcd.setCursor(16, 1);
      if (secs < 10) lcd.print('0');
      lcd.print(secs);
    }
  }
  if (mode == 0) drawdots(7, 0, dotFlag);
}

// ========================= SETUP ==========================
void setup() {
  Serial.begin(115200);
  Serial.println("=== Rybalkomometr v1.0 ===");

  // Task Watchdog: перезавантажить пристрій якщо loop() зависне > 30 сек
  esp_task_wdt_init(30, true);  // 30 сек таймаут, panic=true → reboot
  esp_task_wdt_add(NULL);       // підписуємо поточну задачу (loop)

  // LEDC для підсвітки і RGB
  ledcSetup(CH_BL, 5000, 8); ledcAttachPin(BACKLIGHT,  CH_BL);
  ledcSetup(CH_R,  5000, 8); ledcAttachPin(LED_R_PIN,  CH_R);
  ledcSetup(CH_G,  5000, 8); ledcAttachPin(LED_G_PIN,  CH_G);
  ledcSetup(CH_B,  5000, 8); ledcAttachPin(LED_B_PIN,  CH_B);

  setLcdBright(LCD_BRIGHT_MAX);
  setRGB(200, 140, 0);  // жовтий — очікування першого розрахунку

  pinMode(BTN_PIN, INPUT);

  Wire.begin(21, 22);

  // RTC — ініціалізуємо ПЕРШИМ після Wire, бо loadSunTimes() викликає rtc.now()
  if (rtc.begin()) {
    Serial.println("RTC: OK");
    if (RESET_CLOCK) {
      rtc.adjust(DateTime(F(__DATE__), F(__TIME__)));
      Serial.println("RTC: time set from compile time");
    } else if (rtc.lostPower()) {
      rtc.adjust(DateTime(F(__DATE__), F(__TIME__)));
      Serial.println("RTC: lost power, time set from compile time");
    } else {
      Serial.println("RTC: time OK, not overwriting");
    }
  } else {
    Serial.println("RTC: ERROR!");
  }

  // Завантажуємо базовий тиск (зберігається між прошивками)
  prefs.begin("fish", true);
  float legacyBasePress = prefs.getFloat("basePress", 0.0f);
  pressSlotA   = prefs.getFloat("pressA", legacyBasePress);
  pressSlotB   = prefs.getFloat("pressB", legacyBasePress);
  pressActiveSlot = prefs.getUChar("pressSlot", 0);
  SEA_PRESS_MM = (pressActiveSlot == 0) ? pressSlotA : pressSlotB;
  fishType     = prefs.getUChar("fishType", 0);
  useTime      = prefs.getBool("useTime",   true);
  useSpawn     = prefs.getBool("useSpawn",  true);
  useMoon      = prefs.getBool("useMoon",   true);
  waterType    = prefs.getUChar("waterType", 0);
  tzMode       = prefs.getUChar("tzMode",   0);
  prefs.end();
  Serial.printf("Базовий тиск: %.1f мм (слот %s)\n", SEA_PRESS_MM, pressActiveSlot==0?"A":"B");

  // Завантажуємо WiFi мережі та прогноз
  loadWifiNets();
  loadForecast();
  loadSunTimes(); // відновлюємо схід/захід незалежно від стану прогнозу
  // updateDayCache() викликається ПІСЛЯ rtc.begin() нижче — RTC має бути готовим

  // Підключаємось до WiFi у фоні (не блокуємо старт)
  if (wifiNetCount > 0) {
    WiFi.mode(WIFI_STA);
    WiFi.begin(wifiNets[0].ssid, wifiNets[0].pass);
    wifiConnectStart = millis();
    wifiConnecting = true;
    Serial.print("WiFi try (setup): "); Serial.println(wifiNets[0].ssid);
  }

  // LCD
  lcd.init();
  lcd.backlight();
  lcd.clear();
  lcd.setCursor(0, 0);
  lcd.print("Rybalkomometr v1.0");

  // Тепер RTC ініціалізований — безпечно викликати updateDayCache()
  updateDayCache();

  // BME280
  if (bme.begin(0x76)) {
    Serial.println("BME280: OK (0x76)");
  } else if (bme.begin(0x77)) {
    Serial.println("BME280: OK (0x77)");
  } else {
    Serial.println("BME280: ПОМИЛКА!");
    lcd.setCursor(0, 2); lcd.print("BME ERROR!");
  }

  bme.setSampling(Adafruit_BME280::MODE_FORCED,
                  Adafruit_BME280::SAMPLING_X1,
                  Adafruit_BME280::SAMPLING_X1,
                  Adafruit_BME280::SAMPLING_X1,
                  Adafruit_BME280::FILTER_OFF);

  now = rtc.now();
  secs = now.second();
  mins = now.minute();
  hrs  = now.hour();

  bme.takeForcedMeasurement();
  readSensors();
  resetRuntimePressureState();

  Serial.println("Fresh start");

  delay(1500);
  lcd.clear();

  loadClock();
  drawClock(hrs, mins, 0, 0, true);
  drawData();
  drawSensors();

  // Якщо WiFi вже підключений до рестарту (швидке перепідключення)
  if (WiFi.status() == WL_CONNECTED) {
    wifiConnecting = false;
    staConnected   = true;
    // Переконуємось що AP вимкнена (не роздаємо свій AP якщо є роутер)
    WiFi.mode(WIFI_STA);
    apActive = false;
    apManual = false;
    syncNTP();
    if (!staWebActive) {
      setupWebServer();
      webServer.begin();
      staWebActive = true;
      Serial.print("WebServer (fast reconnect) IP: "); Serial.println(WiFi.localIP());
    }
    drawApBadge();
    // fetchForecast() не викликаємо в setup() — це блокуючий HTTP запит до 15 сек.
    // Ставимо прапорець — loop() виконає його в першій ітерації.
    uint32_t nowTs2b = (uint32_t)((time_t)rtc.now().unixtime() - getUtcOffset());
    if (cityLat != 0.0f && (!forecastValid || (nowTs2b - forecastTimestamp) > 12*3600)) {
      needFetchForecast = true;
    }
  }

  uint32_t ms = millis();
  sensorsTimer_ms    = ms;
  drawTimer_ms       = ms;
  clockTimer_ms      = ms;
  hourPlotTimer_ms   = ms;
  dayPlotTimer_ms    = ms;
  brightTimer_ms     = ms;
  plotRedrawTimer_ms = ms;
  // Після кожного старту тренд тиску рахується з нуля, без старих штрафів із NVS.
  predictTimer_ms = ms;

  // Ініціалізуємо mutex для HTTPClient (має бути до старту будь-яких FreeRTOS-тасків)
  httpMutex = xSemaphoreCreateMutex();

  // При рестарті підтягуємо масив прогнозу до поточної години одразу,
  // не чекаючи першого спрацювання forecastScrollMs (через 1 год) у wifiSyncTick().
  // Без цього перші ~1 год після ребуту forecast[0] може вказувати на минулу годину.
  if (forecastValid && forecastTimestamp > 0) {
    int32_t utcOff = getUtcOffset();
    time_t nowUtcBoot = (time_t)rtc.now().unixtime() - utcOff;
    if (nowUtcBoot > (time_t)forecastTimestamp) {
      int elapsedBoot = (int)((nowUtcBoot - (time_t)forecastTimestamp) / 3600);
      if (elapsedBoot >= 1 && elapsedBoot < FORECAST_HOURS) {
        memmove(forecast, forecast + elapsedBoot,
                (FORECAST_HOURS - elapsedBoot) * sizeof(ForecastHour));
        memset(forecast + FORECAST_HOURS - elapsedBoot, 0,
               elapsedBoot * sizeof(ForecastHour));
        forecastTimestamp += (uint32_t)elapsedBoot * 3600;
        dayCache.valid = false;
        updateDayCache();
        Serial.printf("Boot: forecast scrolled %d h\n", elapsedBoot);
      } else if (elapsedBoot >= FORECAST_HOURS) {
        forecastValid = false;
        forecastTimestamp = 0;
        memset(forecast, 0, sizeof(forecast));
        Serial.println("Boot: forecast exhausted, cleared");
      }
    }
  }
}

// ========================= LOOP ===========================
void loop() {
  esp_task_wdt_reset(); // годуємо watchdog — якщо loop зависне, ESP32 перезавантажиться
  uint32_t ms = millis();

  // Яскравість кожні 50мс (плавно але швидко реагує)
  if (ms - brightTimer_ms >= 50) {
    brightTimer_ms = ms;
    checkBrightness();
  }

  // Читання датчиків
  if (ms - sensorsTimer_ms >= SENS_TIME) {
    sensorsTimer_ms = ms;
    readSensors();
  }

  // Оновлення дисплея датчиків кожні 10 сек
  if (ms - drawTimer_ms >= DRAW_TIME && mode == 0) {
    drawTimer_ms = ms;
    drawSensors();
  }

  // Годинник (двічі на секунду)
  if (ms - clockTimer_ms >= 500) {
    clockTimer_ms = ms;
    clockTick();
  }

  // Веселка якщо кльов рівень 4
  if (calcFishScore() == 3 && ms - rainbowTimer_ms >= 30) {
    rainbowTimer_ms = ms;
    rainbowHue += 3;
    byte r, g, b;
    hsvToRgb(rainbowHue, currentLedBright, r, g, b);
    setRGB(r, g, b);
  }

  // Графіки (таймери всередині)
  plotSensorsTick();

  // WiFi AP обробка
  apTick();
  wifiSyncTick();

  // Кнопка
  modesTick();

  // Перемалювання графіку кожні 4 хв (тільки графіки 1-4, не WiFi екран mode 5)
  if (((mode >= 1 && mode <= 4) || mode == 6) && ms - plotRedrawTimer_ms >= (uint32_t)4*60*1000) {
    plotRedrawTimer_ms = ms;
    redrawPlot();
  }

  // Оновлення WiFi екрану кожні 2 сек (статус STA міг змінитись)
  static uint32_t wifiScreenTimer_ms = 0;
  if (mode == 5 && ms - wifiScreenTimer_ms >= 2000) {
    wifiScreenTimer_ms = ms;
    drawWifiScreen();
  }

  // Перевірка денного кешу щогодини (навіть без WiFi — при зміні дня переключаємо кеш)
  static uint32_t dayCacheCheckMs = 0;
  if (ms - dayCacheCheckMs >= 3600UL * 1000) {
    dayCacheCheckMs = ms;
    updateDayCache();
  }
}